* NGSPICE file created from combinational_multiplier_16x16.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_4 abstract view
.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_4 abstract view
.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd2_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s4s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_2 abstract view
.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

.subckt combinational_multiplier_16x16 VGND VPWR mcand[0] mcand[10] mcand[11] mcand[12]
+ mcand[13] mcand[14] mcand[15] mcand[1] mcand[2] mcand[3] mcand[4] mcand[5] mcand[6]
+ mcand[7] mcand[8] mcand[9] mplier[0] mplier[10] mplier[11] mplier[12] mplier[13]
+ mplier[14] mplier[15] mplier[1] mplier[2] mplier[3] mplier[4] mplier[5] mplier[6]
+ mplier[7] mplier[8] mplier[9] product[0] product[10] product[11] product[12] product[13]
+ product[14] product[15] product[16] product[17] product[18] product[19] product[1]
+ product[20] product[21] product[22] product[23] product[24] product[25] product[26]
+ product[27] product[28] product[29] product[2] product[30] product[31] product[3]
+ product[4] product[5] product[6] product[7] product[8] product[9]
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2106_ _1301_ _0128_ _1068_ _1154_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__nand4_2
XFILLER_0_89_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2037_ _0990_ _0991_ _0993_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_46_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_185_Left_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_791 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_623 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_172_3842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer7 _0609_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_180_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_188_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_156_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_157_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2724_ _0449_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__xor2_1
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2655_ _0367_ _0368_ _0377_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__and3_1
XFILLER_0_112_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1606_ _1107_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__buf_4
XFILLER_0_113_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2586_ _0304_ _0252_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_11_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1537_ _0560_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1468_ _0510_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__xnor2_2
X_1399_ net80 net86 _1312_ _1334_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_87_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_409 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_514 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_150_3414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2440_ _0076_ _0078_ _0146_ _0147_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__a211o_1
XFILLER_0_59_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2371_ _0779_ _0684_ _1293_ _0623_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a22o_1
XFILLER_0_166_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2707_ _0416_ _0421_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2638_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__nor2_1
XFILLER_0_113_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2569_ _0685_ _0000_ net23 _0624_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_26_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_732 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_162_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_167_3741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1940_ _0503_ _0649_ _0587_ _0557_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_185_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1871_ _0703_ _0629_ _0907_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nand4_2
XFILLER_0_126_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_181_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2423_ _0692_ _0123_ _0125_ _0127_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_36_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_987 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2354_ _0003_ _0052_ _0055_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__nand3_1
X_2285_ _0774_ net4 net5 _0640_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_173_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_184_4085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_846 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_721 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2070_ _1226_ _1108_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__nand2_1
XFILLER_0_163_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1923_ _0958_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_189_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_826 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1854_ _1161_ net3 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1785_ _0758_ _0622_ _0683_ _1096_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2406_ _0038_ _0098_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2337_ _0034_ _0037_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2268_ _1179_ _1257_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_0_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2199_ _1186_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__xor2_4
XFILLER_0_189_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_3608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_687 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_156_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_439 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_5 _1085_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1570_ _0532_ _0571_ _0609_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__and4b_1
XFILLER_0_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2122_ _1170_ _1171_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2053_ _1033_ _1095_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__and3_1
XFILLER_0_156_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_543 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1906_ _0941_ _0942_ _0880_ _0881_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__a211o_1
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1837_ _0814_ _0874_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__and3_1
XFILLER_0_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1768_ net68 _0678_ _0738_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_92_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1699_ _0731_ _0732_ _0680_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_181_4022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_4033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_570 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_827 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_153_3478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput42 net42 VGND VGND VPWR VPWR product[18] sky130_fd_sc_hd__clkbuf_4
Xoutput53 net53 VGND VGND VPWR VPWR product[28] sky130_fd_sc_hd__clkbuf_4
Xoutput64 net64 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__buf_2
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_187_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_156_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2740_ _0467_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__or2_1
XFILLER_0_125_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2671_ _0394_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nor2_2
XFILLER_0_42_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_169_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1622_ _0636_ _0662_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__nand3_4
XFILLER_0_151_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1553_ _0593_ _0594_ _0585_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1484_ _0525_ _0526_ _0507_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_185_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2105_ net21 VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2036_ _1076_ _1077_ _1075_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a21o_1
XFILLER_0_166_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_131_3028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_762 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_155_3507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_155_3518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_172_3843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_3854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer8 net81 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_140_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_760 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2723_ _0194_ _0272_ _0419_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a31o_1
XFILLER_0_109_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_902 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2654_ _0367_ _0368_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1605_ net9 _0587_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2585_ _0235_ _0239_ _0237_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_10_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1536_ _0573_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_39_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1467_ _1128_ net12 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
X_1398_ _0999_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_87_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_708 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2019_ _0503_ _0649_ _0760_ _0650_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_102_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_526 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_150_3404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2370_ _0918_ _0746_ _1353_ _1354_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and4_1
XFILLER_0_166_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_157_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2706_ _0432_ _0433_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__xnor2_2
XFILLER_0_160_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2637_ _0358_ _0330_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_58_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2568_ _0284_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_34_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ _0556_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nand2_1
X_2499_ _0134_ _0155_ _0156_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__nand3_2
XFILLER_0_96_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_143_3263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_168_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_903 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_162_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_52_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_584 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_150_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1870_ _0514_ _0503_ _0587_ _0557_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__nand4_2
XFILLER_0_71_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_177_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2422_ _0692_ _0123_ _0125_ _0127_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_36_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2353_ _0051_ _0054_ _0049_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__or3b_1
XFILLER_0_0_999 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2284_ _0640_ _0774_ net5 VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1999_ _1172_ net6 VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_184_4086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_170_Right_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_168_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_733 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1922_ _1021_ net6 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1853_ _0889_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__nor2_2
XFILLER_0_25_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_182_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1784_ _1031_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__nand2_2
XFILLER_0_25_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2405_ _0096_ _0094_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2336_ _0035_ _0036_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_51_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2267_ _1326_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_140_3200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2198_ _1252_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_149_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_186_4126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_161_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_112_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_611 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_6 _1109_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_123_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2121_ _1057_ _1092_ _1091_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_83_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2052_ _1093_ _1094_ _1007_ _1034_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__a211o_1
XFILLER_0_178_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1905_ _0880_ _0881_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_33_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_555 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_163_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1836_ _0872_ _0873_ _0815_ _0801_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_143_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_819 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1767_ _0805_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_2
XFILLER_0_114_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1698_ _0679_ _0738_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_181_4023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2319_ _1299_ _1300_ _1309_ _1308_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__a31o_1
XFILLER_0_100_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_839 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_153_3468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_160_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput43 net65 VGND VGND VPWR VPWR product[19] sky130_fd_sc_hd__clkbuf_4
Xoutput54 net54 VGND VGND VPWR VPWR product[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_179_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_2994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_177_3947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2670_ _0365_ _0366_ _0393_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ _0659_ _0660_ _0661_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a21o_1
XFILLER_0_169_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1552_ _0585_ _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nand3_2
XFILLER_0_111_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1483_ _0507_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__or3_4
XFILLER_0_10_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2104_ _0642_ _0851_ _0922_ _0643_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_89_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2035_ _1075_ _1076_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_99_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_3029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1819_ _0854_ _0855_ _0856_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_155_3508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer9 _1005_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_1
XFILLER_0_122_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_251 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_925 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_188_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_172_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_172_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2722_ _0417_ _0378_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_914 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ _0373_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xor2_1
XFILLER_0_112_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1604_ _0639_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xor2_2
XFILLER_0_140_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2584_ _0183_ _0248_ _0249_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__and3_1
XFILLER_0_140_777 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1535_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_39_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1466_ _0508_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and2b_1
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1397_ net87 net80 net86 _1312_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_87_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2018_ _0649_ _0557_ _0650_ _0503_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__a22o_1
XFILLER_0_132_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_708 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_609 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_174_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_150_3405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_774 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_184_Right_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2705_ _0396_ _0401_ _0394_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2636_ _0330_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__and2b_1
XFILLER_0_113_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2567_ _0143_ _0040_ _0282_ _0283_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__and4_2
XFILLER_0_26_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_151_Right_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1518_ _0558_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2498_ _0060_ _0133_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__or2_1
X_1449_ _0161_ _0236_ _0226_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_183_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_162_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_181_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2421_ _0504_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2352_ _0504_ _0763_ _1154_ _0992_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and4_1
X_2283_ _1289_ _1298_ _1297_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1998_ _1036_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2619_ _0338_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_163_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_2749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_870 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_572 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1921_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nor2_1
XFILLER_0_189_1065 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1852_ _1031_ _1226_ _0820_ _0888_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__and4_2
XFILLER_0_170_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1783_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__buf_6
XFILLER_0_188_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2404_ _0104_ _0109_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__xor2_4
XFILLER_0_23_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2335_ _1333_ _1329_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_51_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2266_ _1186_ _1255_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_140_3201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2197_ _1116_ _1173_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_172_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_140_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_715 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_7 _1315_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_831 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2120_ _1141_ _1169_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2051_ _1007_ net72 _1093_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_107_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_187_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_186_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1904_ net73 _0940_ _0882_ _0868_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_127_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_155_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1835_ _0815_ _0801_ _0872_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a211o_4
XFILLER_0_72_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1766_ _0736_ _0734_ _0803_ _0804_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a22o_1
XFILLER_0_142_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1697_ _0734_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_111_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_181_4024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2318_ _0014_ _0015_ _0004_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_100_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2249_ _1159_ _1236_ _1307_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__or3_1
XFILLER_0_170_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Left_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput33 net33 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__buf_2
Xoutput44 net44 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_129_2984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_Left_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_328 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1620_ _0659_ _0660_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__nand3_4
XFILLER_0_125_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_136_Left_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1551_ _0590_ _0591_ _0592_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1482_ _0522_ _0523_ _0524_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_123_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2103_ net12 _0780_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_89_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_145_Left_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2034_ _1010_ _0648_ net22 net23 VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__nand4_2
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_607 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_3111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_742 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_154_Left_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1818_ _0854_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nand3_1
XFILLER_0_143_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1749_ _0786_ _0787_ _0777_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_163_Left_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_124_2881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_155_3509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_172_Left_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_165_Right_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_904 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_181_Left_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_607 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_219 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2721_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_140_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2652_ _0747_ _0001_ _0374_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_926 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1603_ _0640_ _0641_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2583_ _0300_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_789 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1534_ _1021_ net15 _0574_ _0575_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_10_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1465_ net26 _1290_ _0117_ _1085_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a22o_1
X_1396_ net26 VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2017_ _0978_ _0979_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__nand2_2
XFILLER_0_49_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_161_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_174_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_583 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_148_3368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_423 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_156_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_171_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2704_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2635_ _0356_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2566_ _0143_ _0040_ _0282_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_11_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1517_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__inv_2
X_2497_ _0207_ _0208_ _0185_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o21a_1
XFILLER_0_96_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1448_ _0471_ _0481_ _0386_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1379_ net24 VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_143_3265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_167_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_234 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_119_2791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_551 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_150_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_167_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2420_ _0763_ _0000_ _0001_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2351_ _0049_ _0050_ _0051_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__a21bo_1
X_2282_ _1280_ _1282_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1997_ _1161_ _0758_ net4 net5 VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_99_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_615 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_144_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2618_ _0336_ _0337_ _0192_ _0040_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_11_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2549_ _0256_ _0257_ _0264_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_184_4099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_183_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_551 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_149_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_705 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_702 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_882 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_584 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_186_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1920_ _1096_ _1128_ net4 net5 VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__and4_1
XFILLER_0_139_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1851_ _1226_ _0821_ _0888_ _1031_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_155_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1782_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_25_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_771 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2403_ _1182_ _1330_ _0105_ _0108_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2334_ _1326_ _1328_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_51_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2265_ _1252_ _1254_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2196_ _1170_ _1171_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_0_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_189_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_705 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_3164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_3175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_160_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_112_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_179_3990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_727 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_8 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_132_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_843 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_602 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _1091_ _1092_ _1057_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21o_1
XFILLER_0_178_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_179_Right_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_187_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1903_ _0882_ _0868_ net73 _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a211o_2
XFILLER_0_17_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1834_ _0870_ _0871_ _0817_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_96_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1765_ _0736_ _0734_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_133_3072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_810 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1696_ _0606_ _0735_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_111_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_181_4025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2317_ _0004_ _0014_ _0015_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__and3_1
XFILLER_0_32_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2248_ _1159_ _1236_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__o21a_1
XFILLER_0_170_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2179_ _1117_ _0992_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_68_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_157_3540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_157_3551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_811 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput34 net34 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__clkbuf_4
Xoutput45 net45 VGND VGND VPWR VPWR product[20] sky130_fd_sc_hd__buf_2
Xoutput56 net56 VGND VGND VPWR VPWR product[30] sky130_fd_sc_hd__buf_6
XFILLER_0_179_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_184_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1550_ _0590_ _0591_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand3_2
XFILLER_0_1_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1481_ _0522_ _0523_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__and3_4
XFILLER_0_162_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2102_ _1142_ _1149_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_89_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2033_ _0648_ net22 net23 _1334_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a22o_1
XFILLER_0_178_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_619 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_174_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1817_ _0778_ _0782_ _0781_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1748_ _0777_ _0786_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__nand3_1
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1679_ _0710_ _0718_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__nand3_2
XFILLER_0_111_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_172_3846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_619 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_172_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2720_ _0434_ _0446_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__or2_1
XFILLER_0_171_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2651_ _0685_ _0178_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_938 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1602_ _0642_ net84 net88 _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a22o_1
X_2582_ _0254_ _0299_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1533_ _0574_ _0575_ _1021_ net15 VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1464_ _1085_ net26 net10 net11 VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1395_ _1290_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_59_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2016_ _0984_ _1003_ _1004_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_65_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_150_3418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_126_2922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_182_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2703_ _0426_ _0428_ _0402_ _0403_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__o211a_1
XFILLER_0_171_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2634_ _1222_ _0272_ _0308_ _0307_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_152_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2565_ _0192_ _0194_ _0822_ _0281_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand4_2
XFILLER_0_10_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1516_ net17 net24 net13 net14 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__and4_1
XFILLER_0_10_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2496_ _0185_ _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nor3_2
X_1447_ _0386_ _0471_ _0481_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1378_ net86 VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_12_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_167_3756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_186_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_563 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_736 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2350_ _0692_ _1068_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_36_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2281_ _1341_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_53_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1996_ _0758_ net4 net5 _1161_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_71_931 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_627 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2617_ _0192_ _0040_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_3_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2548_ _0256_ _0257_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_184_4089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2479_ _0918_ _0040_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_162_3642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_714 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1850_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__buf_4
XFILLER_0_86_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1781_ net4 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_181_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2402_ _0035_ _0106_ _0105_ _1332_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a221o_1
XFILLER_0_62_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2333_ _1336_ _0033_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2264_ _1261_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2195_ _1192_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_138_3165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_3176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1979_ _0945_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_186_4129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_112_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_3991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_739 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_9 net36 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_855 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1902_ _0902_ _0903_ _0937_ _0938_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__o22a_1
XFILLER_0_139_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1833_ _0817_ _0870_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_96_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_133_3062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1764_ _0801_ _0802_ _0731_ _0739_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_133_3073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_822 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1695_ _0670_ _0671_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_4026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2316_ _0012_ _0013_ _0005_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2247_ _1303_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2178_ _1230_ _1231_ _1229_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21o_1
XFILLER_0_164_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_308 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_823 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput35 net35 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR product[21] sky130_fd_sc_hd__clkbuf_4
Xoutput57 net57 VGND VGND VPWR VPWR product[31] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_179_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_179_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_183_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1480_ _0386_ _0481_ _0471_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_123_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2101_ _1147_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_89_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2032_ net9 _0922_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__and2_1
XFILLER_0_168_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1816_ _0852_ _0853_ _0850_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1747_ _0783_ _0784_ _0785_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_68_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1678_ _0715_ _0716_ _0717_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_124_2894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_172_3847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_642 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_402 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_86_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_95_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_171_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_388 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2650_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_180_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_130_3010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1601_ _1290_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_140_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2581_ _0254_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand2_1
XFILLER_0_160_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1532_ net25 net24 net13 net14 VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_39_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1463_ _0506_ _0505_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1394_ net10 VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__buf_6
XFILLER_0_38_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2015_ _1055_ _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_150_3419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_703 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_799 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_508 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_148_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2702_ _0402_ _0403_ _0426_ _0428_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_160_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2633_ _0353_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2564_ _0194_ _0821_ _0281_ _0192_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1515_ _1128_ _0503_ _0557_ _1021_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a22o_1
X_2495_ _0205_ _0206_ _0186_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1446_ _0439_ _0450_ _0461_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1377_ net8 VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_143_3267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_244 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_167_3746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_167_3757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_575 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_182_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2280_ _0638_ net7 VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1995_ _0976_ _0982_ _0981_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_943 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_172_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2616_ _0194_ _0821_ _0123_ _0888_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_2690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2547_ _0262_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2478_ _0187_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1429_ _0086_ _0290_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_162_3643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_149_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_164_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_680 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_544 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_186_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1780_ _0756_ _0769_ _0767_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_154_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2401_ _1336_ _0033_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2332_ _1337_ _0031_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2263_ _1321_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2194_ _1247_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_140_3215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1978_ _0949_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__xor2_4
XFILLER_0_173_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_179_3992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_720 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_878 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1901_ _0902_ _0903_ _0937_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nor4_1
XFILLER_0_167_591 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1832_ _0868_ _0869_ _0818_ _0797_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_115_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_466 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_160_Right_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1763_ _0731_ _0739_ _0801_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_40_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_133_3063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1694_ _0670_ _0671_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__xor2_1
XFILLER_0_110_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_181_4027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2315_ _0005_ _0012_ _0013_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__nand3_1
X_2246_ _1304_ _1305_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2177_ _1229_ _1230_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_178_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput36 net36 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput47 net47 VGND VGND VPWR VPWR product[22] sky130_fd_sc_hd__clkbuf_4
Xoutput58 net58 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__buf_2
XFILLER_0_179_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_618 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_810 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_876 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_580 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2100_ _1145_ _1146_ _1070_ _1071_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a211o_1
XFILLER_0_94_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2031_ _1071_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nor2_2
XFILLER_0_77_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_114_Left_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_187_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_509 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_155_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1815_ _0850_ _0852_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_3450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1746_ _0783_ _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nand3_1
XFILLER_0_142_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1677_ _0715_ _0716_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_123_Left_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2229_ _1284_ _1285_ _1268_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_107_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_132_Left_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_161_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_Left_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_161_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_150_Left_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_509 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_3000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1600_ _0117_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_130_3011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2580_ _0297_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1531_ _1085_ net13 net14 _1128_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_121_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1462_ _1031_ _0504_ net77 _0502_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_39_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1393_ _1269_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_180_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_242 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2014_ _1052_ _1054_ _0967_ _0969_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_65_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_687 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_715 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1729_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nor2_1
XFILLER_0_112_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_940 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_746 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_156_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_184_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_339 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2701_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_704 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2632_ _0300_ _0310_ _0302_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_180_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_152_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2563_ _0888_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1514_ net14 VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__buf_6
XFILLER_0_140_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2494_ _0186_ _0205_ _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__and3_1
X_1445_ _0439_ _0450_ _0461_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1376_ _1085_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_3268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_2821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_418 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_163_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_167_3747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_189_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_738 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_306 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1994_ _0973_ _0974_ _1007_ _1008_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nor4_1
XFILLER_0_172_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_188_4161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_188_4172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2615_ _0822_ _0123_ _0281_ _0194_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_141_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_578 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2546_ _0918_ _1108_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_114_2680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2477_ _1222_ _0143_ _0821_ _0888_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_145_3319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1428_ _0258_ _0280_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_174_Right_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_478 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_556 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_740 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2400_ _0033_ _1336_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_94_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2331_ _0028_ _0030_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2262_ _1192_ _1251_ _1322_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_179_Left_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2193_ _1141_ _1169_ _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_140_3216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_896 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_138_3167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_188_Left_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1977_ _1014_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nand2_2
XFILLER_0_71_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2529_ _0241_ _0242_ _0746_ _1068_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_39_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_179_3982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_179_3993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_732 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_415 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_160_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1900_ _0935_ _0936_ _0862_ _0904_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__o211a_1
XFILLER_0_155_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1831_ _0818_ _0797_ _0868_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__o211a_2
XFILLER_0_154_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_478 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1762_ _0799_ _0800_ _0689_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_170_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_133_3064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_3075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1693_ _0680_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_123_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_181_4028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2314_ _0009_ _0011_ _0006_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2245_ _1301_ _0128_ _0992_ net23 VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand4_1
X_2176_ _0643_ _0642_ _0922_ net22 VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__nand4_2
XFILLER_0_135_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_157_3554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput37 net66 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__clkbuf_4
Xoutput48 net48 VGND VGND VPWR VPWR product[23] sky130_fd_sc_hd__buf_2
Xoutput59 net59 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_129_2988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_822 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2030_ _0705_ _0779_ _1069_ _1070_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_89_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_135_3104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_3115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1814_ _0648_ _0780_ _0851_ _1334_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_152_3451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1745_ _0711_ _0714_ _0713_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_170_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1676_ _0647_ _0653_ _0652_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2228_ _1268_ _1284_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_107_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2159_ _1209_ _1210_ _1195_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_2885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_176_3930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_754 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_632 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_438 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_3001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1530_ _1096_ _0501_ _0549_ _0548_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a31o_1
XFILLER_0_22_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1461_ net76 _0502_ _1031_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__o211a_1
XFILLER_0_129_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1392_ _1248_ _1259_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__and2_2
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2013_ _0967_ _0969_ _1052_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_78_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_699 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1728_ _0765_ _0766_ _0757_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1659_ _0698_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or2_2
XFILLER_0_111_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_805 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_188_Right_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_758 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2700_ _0405_ _0406_ _0425_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a21o_1
XFILLER_0_171_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_532 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2631_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nor2_1
XFILLER_0_113_716 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2562_ _0278_ _0279_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1513_ _1172_ _0501_ _0509_ _0508_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a31o_1
XFILLER_0_121_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2493_ _0202_ _0203_ _0131_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__a21o_1
X_1444_ _0172_ _0193_ _0182_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_147_3350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1375_ net25 VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_155_Right_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_156_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_143_3269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_167_3759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_182_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1993_ _1027_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_172_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2614_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_188_4173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2545_ _0260_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_114_2681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2476_ _0143_ _0821_ _0888_ _1222_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_103_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1427_ _0269_ _0053_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_162_3656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_761 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2330_ _1267_ _1320_ _0029_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2261_ _1250_ _1247_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__or2b_1
XFILLER_0_137_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2192_ _1167_ _1168_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_140_3206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_140_3217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_138_3168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1976_ _1012_ _1013_ _0952_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_2721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_310 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2528_ _0747_ _0194_ _0241_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2459_ _0110_ _0111_ _0167_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__or3_1
XFILLER_0_39_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_503 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_160_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1830_ _0866_ _0867_ _0833_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_167_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1761_ _0689_ _0799_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__or3_4
XFILLER_0_163_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1692_ _0731_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__or2b_4
XFILLER_0_123_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_181_4029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2313_ _0006_ _0009_ _0011_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2244_ _0128_ net22 net23 _1301_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2175_ _0642_ net21 net22 _0643_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_109_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_157_3544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_906 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_174_3891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1959_ _0921_ _0923_ _0924_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_583 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput38 net38 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__clkbuf_4
Xoutput49 net49 VGND VGND VPWR VPWR product[24] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_3105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_3116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1813_ _1010_ _1117_ _0780_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nand4_2
XFILLER_0_143_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_152_3441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1744_ _0781_ _0782_ _0778_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1675_ _0713_ _0714_ _0711_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a21o_1
XFILLER_0_141_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2227_ _1282_ _1283_ _1270_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_907 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2158_ _1195_ _1209_ _1210_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_2897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2089_ _1119_ _1134_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_176_3931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_766 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_917 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_169_Right_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_55_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_168_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_184_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_530 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_3002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1460_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__buf_6
X_1391_ _1215_ _1237_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _1050_ _1051_ _1035_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_166_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_187_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_65_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_169_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1727_ _0757_ _0765_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1658_ _1161_ _0629_ _0696_ _0697_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_169_3790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1589_ net80 _1312_ net13 _0557_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and4_1
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_544 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2630_ _0344_ _0350_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2561_ _0225_ _0227_ _0229_ _0231_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_51_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1512_ _0552_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_58_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2492_ _0131_ _0202_ _0203_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nand3_1
X_1443_ _0418_ _0429_ _0397_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_147_3340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1374_ net9 VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_179_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_121_2823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2759_ _0486_ _0488_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__xor2_4
XFILLER_0_41_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139_603 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_864 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1992_ _1029_ _1030_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__and2b_1
XFILLER_0_185_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2613_ _0287_ _0291_ _0288_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_188_4163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_547 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_188_4174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2544_ _0187_ _0190_ _0188_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_2_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2475_ _0148_ _0151_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1426_ _1139_ _1193_ _0021_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_103_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_889 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_764 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_504 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_189_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_506 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2260_ _1267_ _1320_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__xnor2_2
X_2191_ _1216_ _1246_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__xor2_4
XFILLER_0_137_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_140_3218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_185_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_507 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1975_ _0952_ _1012_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_650 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_439 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2527_ _0623_ _0684_ _1154_ _0992_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2458_ _0110_ _0111_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1409_ _1248_ _0075_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__nor2_2
X_2389_ _0092_ _0093_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_810 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_179_3995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_609 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1760_ _0797_ _0798_ _0727_ _0740_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_96_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_672 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1691_ _0729_ _0730_ _0666_ _0668_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_107_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_111_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2312_ _0759_ _1293_ _0007_ _0008_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__nand4_2
XFILLER_0_0_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2243_ net12 _0922_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__and2_1
X_2174_ net12 _0851_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__and2_1
XFILLER_0_189_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_109_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_180_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_174_3881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_918 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_174_3892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1958_ _0991_ _0993_ _0990_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a21o_1
XFILLER_0_189_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1889_ _0850_ _0853_ _0852_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput39 net39 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_102_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_916 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_152_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap70 _0872_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_98_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1812_ net20 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__buf_4
XFILLER_0_115_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_586 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_152_3453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1743_ _0778_ _0781_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1674_ _0711_ _0713_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2226_ _1270_ _1282_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2157_ _1207_ _1208_ _1200_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_919 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_177_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2088_ _1132_ _1133_ _1124_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_176_3921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_180_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_929 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_130_3003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1390_ _1215_ _1237_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__nand2_1
X_2011_ _1035_ _1050_ _1051_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and3_1
XFILLER_0_145_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_159_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_534 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_247 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_409 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1726_ _0758_ _0629_ _0761_ _0764_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a22o_1
XFILLER_0_124_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1657_ _0696_ _0697_ _1161_ net15 VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_169_3780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1588_ _1172_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2209_ _0758_ net7 VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__nand2_1
XFILLER_0_179_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_410 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_174_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_586 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_184_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_153_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2560_ _0276_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__nor2_4
XFILLER_0_106_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1511_ _0545_ _0546_ _0551_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_58_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2491_ _0200_ _0201_ _0191_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_58_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1442_ _0397_ _0418_ net85 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_147_3341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1373_ _1053_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_121_2824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_176_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_2786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2758_ _0456_ _0462_ _0477_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_131_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1709_ _1031_ _0747_ _0748_ _0744_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_100_902 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2689_ _0332_ _0408_ _0413_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__or3b_1
XFILLER_0_2_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_162_662 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1991_ _0971_ _0973_ _1028_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__or3b_1
XFILLER_0_51_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2612_ _0331_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_188_4164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2543_ _0186_ _0206_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_2694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_581 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2474_ _0183_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__or2_1
XFILLER_0_103_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1425_ _0161_ _0247_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_164_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_148_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_570 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_776 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_516 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_437 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_139_Left_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2190_ _1243_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_140_3208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_3219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_177_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_148_Left_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_519 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1974_ _1009_ _1011_ _0937_ net90 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__a211o_1
XFILLER_0_44_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_662 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_470 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_157_Left_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2526_ _0685_ _1154_ _0000_ _0624_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_140_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2457_ _0113_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__xnor2_1
X_1408_ _0053_ _0064_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__nand2_1
X_2388_ _0090_ _0091_ _0046_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_166_Left_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_175_Left_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_184_Left_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_684 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_3067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1690_ _0666_ _0668_ _0729_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_185_4101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_3078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2311_ _0759_ _1293_ _0007_ _0008_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2242_ _1299_ _1300_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__and2_2
XFILLER_0_100_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2173_ _1217_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_178_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_109_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_189_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_174_3882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_174_3893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1957_ _0990_ _0991_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand3_1
XFILLER_0_145_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_161_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1888_ _0923_ _0924_ _0921_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a21o_1
XFILLER_0_141_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2509_ net75 net69 _0221_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_110_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_928 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_652 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_164_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_633 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_3107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_891 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_779 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1811_ _1074_ _0712_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__and2_1
XFILLER_0_170_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_152_3443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_3454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1742_ _0648_ _0712_ _0780_ _1334_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__a22o_1
XFILLER_0_170_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1673_ _0648_ _0650_ _0712_ _1334_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a22o_1
XFILLER_0_123_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_183_Right_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2225_ _1280_ _1281_ _1275_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2156_ _1200_ _1207_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand3_1
XFILLER_0_178_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_178_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2087_ _1124_ _1132_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_124_2899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_493 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_702 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_911 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_150_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_736 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_152_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_130_3015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_145_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2010_ _1048_ _1049_ _1040_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a21o_1
XFILLER_0_171_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_171_3830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1725_ _0758_ _0759_ _0761_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__nand4_1
XFILLER_0_14_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1656_ _0637_ _0503_ _0557_ _1312_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_169_3781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1587_ net15 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__buf_6
XFILLER_0_186_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ _1263_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2139_ _1188_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__nor2_2
XFILLER_0_179_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_920 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_422 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_162_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1510_ _0512_ _0521_ _0520_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2490_ _0191_ _0200_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_58_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1441_ _1107_ net27 _0407_ _0999_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_147_3342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1372_ _1010_ _1042_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__and2_2
XFILLER_0_171_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_119_2787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2757_ _0478_ _0475_ _0476_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_143_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1708_ _0743_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2688_ _0332_ _0408_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_100_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1639_ _1042_ _0624_ _0621_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and3_2
XFILLER_0_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_706 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_674 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_3250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1990_ _0971_ _0973_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_185_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_888 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2611_ _0685_ _0747_ _0000_ _0001_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__and4_1
XFILLER_0_153_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2542_ _0131_ _0202_ _0203_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_2684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2473_ _0179_ _0180_ _0181_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_121_593 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1424_ _0226_ _0236_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__and2b_1
XFILLER_0_103_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_162_3648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_162_3659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_750 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_164_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_788 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_167_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_166_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_572 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_183_4062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_3209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_722 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1973_ _0937_ net90 _1009_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_29_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_161_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_154_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_674 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_482 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2525_ _0238_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__xnor2_1
X_2456_ _0164_ _0165_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__or2b_1
X_1407_ _1042_ _1301_ _0042_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__a21o_1
X_2387_ _0046_ _0090_ _0091_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_179_3986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_179_3997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_880 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_3068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_164_Right_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2310_ _0762_ _0763_ _0851_ _0922_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__nand4_2
XFILLER_0_21_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2241_ _1297_ _1298_ _1289_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2172_ _1224_ _1225_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__or2b_2
XTAP_TAPCELL_ROW_109_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1956_ _1334_ _0648_ _0922_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nand4_2
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1887_ _0921_ _0923_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__nand3_1
XFILLER_0_31_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2508_ _0213_ _0214_ _0220_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__or3_4
XFILLER_0_110_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2439_ _0143_ _0747_ _0144_ _0145_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__and4_2
XFILLER_0_169_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_600 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_482 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_4010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap72 _1034_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_168_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1810_ _0845_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_128_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_150_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_3444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1741_ _1010_ _1117_ _0779_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_152_3455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1672_ _1010_ _1117_ _0651_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nand4_2
XFILLER_0_29_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_159_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2224_ _1275_ _1280_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__nand3_1
XFILLER_0_139_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_128_2970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2155_ _1203_ _1205_ _1206_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2086_ _1129_ _1130_ _1131_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_714 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_382 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1939_ _0908_ _0909_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nand2_2
XFILLER_0_47_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_748 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_3005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_3016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_175_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_171_3820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_3831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1724_ _0637_ _0703_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nand4_2
XFILLER_0_13_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1655_ net26 _0637_ net13 _0557_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__and4_1
XFILLER_0_110_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1586_ _0581_ _0582_ _0583_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_169_3793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _1211_ net74 _1262_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_179_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2138_ _1136_ _1138_ _1187_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_178_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_179_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_932 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2069_ _1112_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__nor2_1
XFILLER_0_178_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1440_ _0999_ _1107_ net27 _0407_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand4_2
XFILLER_0_49_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1371_ _1031_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_147_3343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_547 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_119_2788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2756_ _0484_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor2_2
XFILLER_0_83_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1707_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2687_ _0411_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1638_ net68 _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__nor2_2
XFILLER_0_1_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1569_ _0610_ _0608_ _0571_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_166_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_743 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_3240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_710 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2610_ _0747_ _0178_ _0001_ _0685_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_153_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_188_4166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_188_4177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2541_ _0209_ _0254_ _0255_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand3_1
XFILLER_0_51_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2472_ _0179_ _0180_ _0181_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_114_2685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_2696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1423_ _0204_ _0215_ _1323_ _1355_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__a211o_1
XFILLER_0_142_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_162_3649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_762 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_178_Right_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2739_ _0444_ _0464_ _0466_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_551 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_145_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_158_734 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_185_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1972_ _0973_ _0974_ _1007_ _1008_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_44_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_116_2725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_768 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2524_ _1222_ _0040_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_892 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2455_ _0162_ _0163_ _0090_ _0092_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__o211ai_1
X_1406_ _1042_ _1301_ _0042_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__nand3_1
X_2386_ net71 _0089_ _0019_ _0022_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_179_3998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_450 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_98_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_182_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_3069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_185_4114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2240_ _1289_ _1297_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2171_ _1221_ _1223_ _1218_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__a21o_1
XFILLER_0_164_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_157_3548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_157_3559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_174_3895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1955_ net22 VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_161_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_910 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1886_ _1010_ _1117_ _0851_ _0922_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__nand4_2
XFILLER_0_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2507_ _0213_ _0214_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_51_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2438_ _0143_ _0747_ _0144_ _0145_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a22oi_2
X_2369_ _1354_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_180_4000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap73 _0939_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_183_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_3109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1740_ net19 VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__buf_4
XFILLER_0_136_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1671_ net18 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__buf_4
XFILLER_0_7_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2223_ _1278_ _1279_ _1202_ _1203_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_178_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_128_2960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2154_ _1203_ _1205_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__nand3_1
XFILLER_0_75_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2085_ _1129_ _1130_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nand3_1
XFILLER_0_178_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_186_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_159_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_394 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1938_ _0914_ _0933_ _0934_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nand3_2
XFILLER_0_146_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1869_ _0503_ _0587_ _0557_ net88 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_3006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_410 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_159_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_627 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_171_3821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1723_ _0557_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__buf_6
XFILLER_0_14_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1654_ _0694_ _0641_ _0645_ _0639_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_110_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_169_3783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1585_ _0575_ _0576_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_169_3794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2206_ _1211_ net74 _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_178_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2137_ _1136_ _1138_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_14_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2068_ _1052_ _1055_ _1111_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_76_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_944 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_690 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_456 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_695 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_334 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1370_ _1021_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_147_3344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_164_3680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_Right_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_121_2827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_162_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_559 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_2789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2755_ _0468_ _0473_ _0483_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1706_ net3 VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_170_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2686_ _0123_ _0041_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand2_1
X_1637_ net82 _0672_ _0674_ _0614_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_1_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1568_ _0530_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__inv_2
XFILLER_0_39_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1499_ _0539_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_33_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_179_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_570 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_150_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_109_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_570 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2540_ _0254_ _0255_ _0209_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_188_4178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2471_ _0692_ _0123_ _0125_ _0126_ _0504_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_114_2686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_2697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1422_ _1323_ _1355_ _0204_ _0215_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o211a_1
XFILLER_0_183_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_176_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2738_ _0464_ _0466_ _0444_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_131_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2669_ _0365_ _0366_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_100_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_858 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_183_4064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_157_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_159_3590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1971_ _0973_ _0974_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or4_4
XFILLER_0_56_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_117_Left_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2523_ _0235_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2454_ _0090_ _0092_ _0162_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a211oi_1
XPHY_EDGE_ROW_126_Left_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1405_ _0021_ _0032_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__xnor2_1
X_2385_ _0019_ _0022_ net71 _0089_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a211o_1
XFILLER_0_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 mcand[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_8
XFILLER_0_151_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_179_3988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_179_3999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_135_Left_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_390 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_144_Left_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_153_Left_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_155_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_861 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_137_3151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_185_4104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_185_4115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_Left_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_111_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2170_ _1218_ _1221_ _1223_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__and3_1
XFILLER_0_164_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_171_Left_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_510 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_157_3549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1954_ _0648_ _0922_ net22 _1334_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_174_3885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1885_ _0648_ _0851_ _0922_ _1334_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a22o_1
XFILLER_0_142_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_180_Left_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_484 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2506_ _0218_ _0219_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2437_ _0624_ _0685_ _1293_ _1068_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__nand4_2
XFILLER_0_44_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2368_ _0069_ _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__xor2_1
XFILLER_0_138_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2299_ _1360_ _1361_ _1346_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__a21o_1
XFILLER_0_168_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_160_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_443 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_487 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_180_4001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_874 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap74 _1213_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_104_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_104_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_155_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_183_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_182_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_152_3446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1670_ net9 _0649_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and2_1
XFILLER_0_151_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2222_ _1202_ _1203_ _1278_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__a211o_1
XFILLER_0_178_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_128_2961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2153_ _1125_ _1126_ _1127_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2084_ _1041_ _1043_ _1044_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_177_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1937_ _0971_ _0972_ _0953_ _0954_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__o211a_1
XFILLER_0_12_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1868_ _0846_ _0847_ _0501_ _0774_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__and4b_1
XFILLER_0_82_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1799_ _0703_ net88 _0760_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_680 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_422 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_171_3833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1722_ net13 VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__buf_4
XFILLER_0_170_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1653_ _0640_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1584_ _0621_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_169_3784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2205_ _1196_ _1199_ _1197_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2136_ _1120_ _1123_ _1121_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_178_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2067_ _1052_ _1055_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_166_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_650 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2754_ _0468_ _0473_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nor3_1
XFILLER_0_83_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1705_ _0743_ _0744_ _1021_ net3 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__and4b_1
XFILLER_0_42_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2685_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and2_1
XFILLER_0_151_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1636_ _0614_ _0674_ _0676_ net89 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__a211oi_2
XFILLER_0_1_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1567_ net91 _0572_ net93 _0605_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_111_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1498_ net8 net29 net30 net1 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_33_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2119_ _1167_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_527 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_582 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_157_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_439 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_188_4168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_188_4179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _0692_ _0126_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_114_2687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1421_ _0182_ _0193_ _0172_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_166_3721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_508 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2737_ _0272_ _0436_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_70_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_850 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2668_ _0390_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_2
X_1619_ _0585_ _0594_ _0593_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_35_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2599_ _0318_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__and2_2
XFILLER_0_1_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_382 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1970_ _1005_ _1006_ _0933_ _0975_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_159_3580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_791 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_181_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_116_2738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_390 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2522_ _0143_ _1293_ _0820_ _0888_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ _0159_ _0160_ _0119_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o21a_1
XFILLER_0_121_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1404_ _1139_ _1193_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__nor2_1
X_2384_ _0062_ _0063_ _0085_ _0087_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__o22a_1
Xinput2 mcand[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_4
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_179_3989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_160_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_3141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_873 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_791 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_185_4105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_691 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_158_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1953_ _1074_ _0851_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_174_3886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1884_ net21 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__buf_4
XFILLER_0_25_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_496 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2505_ _0844_ _1108_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_1
XFILLER_0_179_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2436_ _0684_ _1293_ _1068_ _0623_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a22o_1
X_2367_ _0694_ _0040_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2298_ _1346_ _1360_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__nand3_1
XFILLER_0_169_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_499 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_680 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_4002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_152_3447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_3458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_488 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2221_ _0844_ net3 _1276_ _1277_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__and4_2
X_2152_ _0694_ _0746_ _1201_ _1202_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_128_2962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2083_ _1126_ _1127_ _1125_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a21o_1
XFILLER_0_177_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_159_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1936_ _0953_ _0954_ _0971_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_161_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_898 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1867_ _0638_ _0759_ _0839_ _0838_ _0504_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a32o_2
XFILLER_0_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1798_ _0638_ _0759_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2419_ _0504_ _0001_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_164_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_164_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_3019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_159_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_171_3823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1721_ _0703_ _0503_ _0760_ _0637_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1652_ _1226_ _0692_ _0632_ _0631_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__a31o_1
XFILLER_0_151_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1583_ _1042_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_169_3785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_169_3796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2204_ _1161_ _1109_ _1190_ _1189_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__a31o_1
X_2135_ _1226_ _1109_ _1114_ _1113_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a31o_2
XFILLER_0_117_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2066_ _1036_ _1039_ _1037_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_151_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1919_ _1096_ net4 net5 _1128_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_5_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_904 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_902 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_173_Right_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_168_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_712 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_2829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_732 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_182_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2753_ _0480_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1704_ _1096_ net16 net2 _1128_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2684_ _0822_ _0281_ _0178_ _0047_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nand4_2
X_1635_ _0614_ _0615_ _0619_ _0674_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__nor4b_4
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1566_ _0530_ _0606_ _0607_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__or4b_4
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_299 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1497_ net9 net28 VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_33_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2118_ _1067_ _1088_ _1087_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_178_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2049_ _1057_ _1091_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nand3_1
XFILLER_0_178_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_594 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_159_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_3243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_721 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_188_4169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1420_ _0172_ _0182_ _0193_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_114_2699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_184_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_612 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_656 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_4_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2736_ _0281_ _1109_ _0047_ _0041_ _0178_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_171_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2667_ _0143_ _0272_ _0348_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a31o_1
XFILLER_0_140_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1618_ _0657_ _0658_ _0646_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2598_ _0270_ _0275_ _0317_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__or3_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1549_ _0540_ _0541_ _0539_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_158_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_497 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_183_4066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_394 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_161_3630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_159_3581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_178_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2521_ _1293_ _0821_ _0888_ _0143_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_12_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _0119_ _0159_ _0160_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__nor3_1
X_1403_ _1355_ _0010_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2383_ _0062_ _0063_ _0085_ _0087_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__nor4_1
XFILLER_0_39_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput3 mcand[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_8
XFILLER_0_176_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_860 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2719_ _0434_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nand2_1
XFILLER_0_160_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_155_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_3142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_3153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1952_ _0987_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__nor2_2
XFILLER_0_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_174_3887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1883_ _1074_ _0780_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_467 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2504_ _0216_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2435_ _0779_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__buf_4
XFILLER_0_138_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2366_ _0821_ _0067_ _0068_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_138_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2297_ _1358_ _1359_ _1351_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a21o_1
XFILLER_0_155_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_132_3050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_692 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_4003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2220_ _0844_ _0746_ _1276_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_175_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2151_ _0694_ _0746_ _1201_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_128_2963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2082_ _1125_ _1126_ _1127_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__nand3_1
XFILLER_0_88_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_187_Right_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_176_3927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_176_3938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_174_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1935_ _0969_ _0970_ _0955_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_20_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1866_ _0843_ _0862_ _0863_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1797_ _0771_ _0775_ _0773_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_114_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2418_ _0763_ _0992_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__and2_1
X_2349_ _0504_ _0763_ _1154_ _0000_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__nand4_1
XFILLER_0_98_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_903 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_154_Right_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_168_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_177_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_3009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_169_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_171_3824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_3835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1720_ net14 VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__buf_4
XFILLER_0_182_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1052 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1651_ _0629_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__buf_6
XFILLER_0_112_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_184_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1582_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__buf_6
XFILLER_0_106_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_169_3786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_169_3797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2203_ _1257_ _1260_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__xnor2_4
XFILLER_0_28_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2134_ _1110_ _1176_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__a21o_2
XFILLER_0_135_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2065_ _1042_ _1109_ _1032_ _1029_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a31o_1
XFILLER_0_89_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_710 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1918_ _0905_ _0912_ _0911_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_916 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1849_ net5 VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_60_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_917 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_632 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2752_ _0047_ _0272_ _0465_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_143_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1703_ _1096_ _1128_ net16 net2 VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and4_1
XFILLER_0_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2683_ _0281_ _0178_ _0047_ _0822_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1634_ _0614_ _0615_ _0619_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o31a_1
XFILLER_0_111_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1565_ _0604_ _0605_ net91 _0572_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1496_ net87 net8 _0514_ net30 VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_33_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2117_ _1151_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_12_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2048_ _1089_ _1090_ _1003_ _1058_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_76_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_356 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_142_3244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_142_3255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_733 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_180_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_152_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_166_3723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_624 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_668 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2735_ _0041_ _0047_ _0272_ _0178_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a22o_1
XFILLER_0_143_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2666_ _0346_ _0285_ _0345_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1617_ _0646_ _0657_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__nand3_2
X_2597_ _0270_ _0275_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_35_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1548_ _0588_ _0589_ _0586_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a21o_1
XFILLER_0_157_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1479_ _0520_ _0521_ _0512_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_105_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_2_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_165_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_161_3620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_198 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_883 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2520_ _0200_ _0202_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2451_ _0157_ _0158_ _0120_ _0121_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__o211a_1
XFILLER_0_121_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1402_ _1226_ _1074_ _1366_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__a21oi_1
X_2382_ _0083_ _0084_ _0065_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 mcand[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_189_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_705 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_872 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_708 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2718_ _0444_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2649_ _0194_ _0040_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_113_Left_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_Left_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_3143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_706 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_154_3490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_185_4107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_852 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_131_Left_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_168_Right_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_140_Left_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1951_ _0705_ _0651_ _0985_ _0986_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_17_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_174_3888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_174_3899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1882_ net79 _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__nor2_2
XFILLER_0_126_443 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2503_ _0844_ _0041_ _0138_ _0137_ _0822_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_141_479 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2434_ _0140_ _0141_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__xor2_1
X_2365_ _0772_ _0820_ _0887_ _0844_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2296_ _1351_ _1358_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__nand3_1
XFILLER_0_155_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_132_3040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_3051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_855 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_4004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_3449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_867 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _0772_ _0774_ _0623_ _0684_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_128_2964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2081_ _0694_ _0844_ _0623_ _0684_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__nand4_2
XFILLER_0_88_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_176_3928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_176_3939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_1101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_174_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1934_ _0955_ _0969_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__and3_2
XFILLER_0_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1865_ _0900_ _0901_ _0883_ _0884_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__o211a_1
XFILLER_0_140_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1796_ _0764_ _0765_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2417_ _1154_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2348_ _0763_ _1154_ _0992_ _0504_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_88_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2279_ _1339_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_915 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_903 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_549 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_171_3836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1650_ _0689_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1581_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2202_ _1177_ _1178_ _1258_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2133_ _1175_ _1174_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__and2b_1
XFILLER_0_117_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2064_ _1108_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1917_ _0891_ _0898_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1848_ _0835_ _0842_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_928 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1779_ _0795_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__inv_2
XFILLER_0_69_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_929 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_620 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_736 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_3359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_828 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2751_ _0178_ _0041_ _0047_ _0272_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_593 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1702_ _0695_ _0700_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_30_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ _0373_ _0376_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__and2b_1
XFILLER_0_152_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1633_ _0614_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nor2_1
XFILLER_0_112_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_151_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1564_ net78 _0570_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__xor2_1
XFILLER_0_111_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1495_ _0507_ _0525_ _0526_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_33_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2116_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__xor2_4
XFILLER_0_146_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_169_Left_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2047_ _1003_ _1058_ _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_81_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_756 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_703 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_178_Left_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_3245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_187_Left_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_174_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_166_3724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_166_3735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_509 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_183_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2734_ _0449_ _0452_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or2b_1
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2665_ _0351_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1616_ _0654_ _0655_ _0656_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
X_2596_ _0314_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_728 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1547_ _0586_ _0588_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__nand3_1
X_1478_ _0512_ _0520_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_52_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_175_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_718 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_149_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_183_4079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_161_3632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_895 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_159_3594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_872 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_178_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2450_ _0120_ _0121_ _0157_ _0158_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__a211oi_2
X_1401_ _1323_ _1344_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__and2b_1
XFILLER_0_121_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2381_ _0065_ _0083_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_9_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 mcand[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_127_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_188_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_884 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_157_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2717_ _0438_ _0443_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2648_ _0369_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__or2_1
XFILLER_0_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2579_ _0245_ _0248_ _0296_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_155_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_3144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_3155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_185_4119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_178_3970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1950_ _0985_ _0986_ _0501_ _0651_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_56_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_174_3889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1881_ _0705_ _0918_ _0915_ _0916_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_25_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2502_ _0135_ _0154_ _0153_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_11_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2433_ _0844_ _0040_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2364_ _0918_ _0844_ _0887_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2295_ _1356_ _1357_ _1352_ _1279_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__a211o_1
XFILLER_0_155_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_155_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_10 net44 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_162_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_180_4005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_180_4016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_388 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_156_3520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_879 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_180_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2080_ _0774_ _0623_ _0684_ _0640_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_176_3929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_591 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1933_ _0967_ _0968_ _0960_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1864_ _0883_ _0884_ _0900_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_127_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 mplier[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_4
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1795_ _0770_ _0791_ _0792_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2416_ _0051_ _0050_ _0049_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__and3b_1
X_2347_ _0008_ _0011_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__nand2_2
XFILLER_0_35_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2278_ _1284_ _1286_ _1338_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_169_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_927 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_712 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_171_3826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_151_586 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1580_ net16 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__buf_6
XFILLER_0_10_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2201_ _1179_ _1182_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2132_ _1179_ _1182_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__xnor2_2
XFILLER_0_117_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2063_ net7 VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__buf_6
XFILLER_0_53_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_826 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_492 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1916_ _0896_ _0897_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand2_1
XFILLER_0_161_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1847_ _0836_ _0841_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__or2b_1
XFILLER_0_114_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1778_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__inv_2
XFILLER_0_124_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_494 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_495 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_748 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_3349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_155_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2750_ _0477_ _0479_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__xnor2_4
XFILLER_0_143_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1701_ _0693_ _0701_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2681_ _0192_ _0272_ _0383_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nand3_1
XFILLER_0_42_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1632_ _0672_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_124_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1563_ net91 _0572_ _0604_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__o211a_4
XFILLER_0_10_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1494_ _0537_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_33_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2115_ _1073_ _1082_ _1081_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a21bo_2
X_2046_ _1087_ _1088_ _1067_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_81_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_768 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_715 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_3246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_166_3725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_188_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_705 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2733_ _0456_ _0462_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__xor2_2
XFILLER_0_82_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_884 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2664_ _0387_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__or2_1
XFILLER_0_152_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1615_ _0654_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__nand3_1
X_2595_ _0918_ _0272_ _0262_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_112_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1546_ net1 net31 net30 net8 VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1477_ _0517_ _0518_ _0519_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_52_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2029_ _1069_ _1070_ _0501_ _0779_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_119_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_749 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_183_4069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_157_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_159_3584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_159_3595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_884 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1400_ _1323_ _1344_ _1172_ _1074_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__and4b_1
X_2380_ _0081_ _0082_ _0066_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_9_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput6 mcand[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_4
XFILLER_0_36_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_486 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2716_ _0438_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_160_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2647_ _0821_ _1154_ _0888_ _0000_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_93_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2578_ _0245_ _0248_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__and3_1
XFILLER_0_168_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1529_ _0568_ _0569_ net78 VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_27_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_182_Right_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_167_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_137_3145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_3156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_185_4109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_354 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1880_ _0772_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__buf_4
XFILLER_0_113_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_189_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2501_ _0211_ _0212_ _0209_ _0210_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2432_ _0821_ _0137_ _0138_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2363_ _0005_ _0013_ _0012_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_63_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2294_ _1352_ _1279_ _1356_ _1357_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_91_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_412 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_11 _0916_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_4006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_180_4017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_81_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_903 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_903 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_663 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1932_ _0960_ _0967_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__nand3_2
XFILLER_0_173_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1863_ _0885_ _0886_ _0899_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 mplier[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_4
Xinput31 mplier[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_4
XFILLER_0_141_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1794_ _0751_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2415_ _0062_ _0063_ _0085_ _0087_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__or4_4
XFILLER_0_58_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2346_ _0001_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__buf_4
XFILLER_0_157_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2277_ _1284_ _1286_ _1338_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__nor3b_1
XTAP_TAPCELL_ROW_88_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_939 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_160_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_149_3380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_123_2863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_171_3838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1033 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_169_3789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2200_ _1185_ _1256_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__xor2_4
XFILLER_0_119_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2131_ _1018_ _1019_ _1106_ _1180_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__a311o_4
X_2062_ _1025_ _1106_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__xnor2_2
XFILLER_0_135_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_152_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_159_698 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1915_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__and2_1
XFILLER_0_173_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1846_ _0823_ _0830_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__or2b_1
XFILLER_0_163_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1777_ _0753_ _0742_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__and2b_1
XFILLER_0_142_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2329_ _1319_ _1317_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_164_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1700_ _0691_ _0727_ _0728_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nand3_2
XFILLER_0_41_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2680_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__inv_2
XFILLER_0_54_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1631_ _0611_ _0608_ _0571_ _0606_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1562_ _0602_ _0603_ _0562_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_111_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1493_ _0535_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2114_ _1157_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2045_ _1067_ _1087_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1829_ _0833_ _0866_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__or3_4
XFILLER_0_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_142_3247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_178_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_588 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_791 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_180_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_2773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_224 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_717 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2732_ _0327_ _0398_ _0457_ _0460_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o31a_4
XFILLER_0_70_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2663_ _0380_ _0385_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__and2_1
XFILLER_0_124_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1614_ _0586_ _0589_ _0588_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_151_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2594_ _0259_ _0207_ _0261_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_10_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1545_ net87 net86 net31 _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_35_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1476_ _0517_ _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_163_Right_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2028_ _0643_ _0642_ net19 net20 VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__and4_1
XFILLER_0_159_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_227 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_161_3623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_690 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput7 mcand[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_4
XFILLER_0_188_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2715_ _0440_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2646_ _0123_ _0281_ _0000_ _0822_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_93_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2577_ _0180_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1528_ net78 _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_22_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1459_ net13 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__buf_8
XFILLER_0_184_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_3157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_154_3482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_154_3493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_178_3972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_396 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_366 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2500_ _0209_ _0210_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__o211a_1
XFILLER_0_40_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2431_ _1222_ _0820_ _0888_ _0918_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2362_ _1358_ _1360_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nand2_1
X_2293_ _0918_ _0746_ _1353_ _1354_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__nand4_2
XFILLER_0_79_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_12 _1021_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_75_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_132_3043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_162_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2629_ _0344_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_180_4007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_4018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_915 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap69 _0162_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_163_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_915 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_694 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_508 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1931_ _0964_ _0965_ _0966_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__a21o_1
XFILLER_0_185_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1862_ _0885_ _0886_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_127_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput10 mcand[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
XFILLER_0_142_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput21 mplier[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_4
Xinput32 mplier[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_2
XFILLER_0_71_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1793_ _0819_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_181_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2414_ _0016_ _0060_ _0061_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2345_ _0044_ _0045_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__xnor2_1
X_2276_ _1271_ _1274_ _1272_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_176_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_145_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_500 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_149_3381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_123_2864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_123_2875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_155_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_171_3839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1045 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1089 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2130_ _1104_ _1105_ _1018_ _1022_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__and4b_1
XFILLER_0_179_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_712 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2061_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__and2b_1
XFILLER_0_178_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_745 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_174_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1914_ _0890_ _0900_ _0902_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1845_ _0828_ _0829_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1776_ _0727_ _0740_ _0797_ _0798_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a211o_1
XFILLER_0_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2328_ _1343_ _0027_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2259_ _1317_ _1319_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_170_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_839 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_177_Right_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_160_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1630_ _0670_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_144_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1561_ _0562_ _0602_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__or3_4
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1492_ _0301_ _0498_ _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_129_Left_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_183_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2113_ _1160_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__xnor2_4
X_2044_ _1083_ _1084_ _1086_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_564 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_Left_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1828_ _0864_ _0865_ _0791_ _0834_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__o211a_1
XFILLER_0_142_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1759_ _0727_ _0740_ _0797_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_57_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_147_Left_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_156_Left_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_118_2774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_165_Left_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_851 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_174_Left_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2731_ _0400_ _0457_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__o21a_1
XFILLER_0_171_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2662_ _0380_ _0385_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_180_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_183_Left_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1613_ _0652_ _0653_ _0647_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a21o_1
XFILLER_0_160_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2593_ _0311_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_151_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1544_ net30 VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_35_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1475_ _0397_ _0429_ _0418_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_157_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2027_ _0128_ _0780_ _1068_ _1301_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_49_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_187_4141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_2671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_161_3624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_159_3586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput8 mcand[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_12
XFILLER_0_127_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2714_ _0123_ _0041_ _0411_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_42_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2645_ _0335_ _0340_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2576_ _0286_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1527_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_22_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1458_ _1021_ _0501_ _0364_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__and3_1
XFILLER_0_184_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1389_ _1010_ _1042_ _1117_ _1226_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__and4_1
XFILLER_0_184_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_414 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_154_3483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2430_ _0918_ _1222_ _0887_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2361_ _0016_ _0060_ _0061_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2292_ _0772_ net3 _1353_ _1354_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_13 net24 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_172_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2628_ _0348_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_180_4008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_180_4019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2559_ _0274_ _0275_ _0223_ _0225_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_108_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_156_3523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_927 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_621 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1930_ _0964_ _0965_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand3_2
XFILLER_0_173_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_687 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1861_ _0891_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_72_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput11 mcand[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 mplier[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_8
X_1792_ _0823_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2413_ _0116_ _0118_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2344_ _0704_ net7 VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__nand2_1
X_2275_ _0758_ _1109_ _1265_ _1264_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__a31o_1
XFILLER_0_165_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_470 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_158_Right_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_805 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_512 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_149_3382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_245 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_171_3829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_940 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_247 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2060_ _1102_ _1103_ _1026_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_634 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1913_ _0900_ _0902_ _0890_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_139_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1844_ _0791_ _0834_ _0864_ _0865_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__a211o_1
XFILLER_0_155_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1775_ _0731_ _0739_ _0801_ _0802_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2327_ _0024_ _0026_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_33_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2258_ _1216_ _1246_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_144_3290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2189_ _1151_ _1166_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__o21a_2
XFILLER_0_149_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_164_3688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_164_3699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_169_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_155_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1560_ _0600_ _0601_ _0555_ _0566_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__o211a_1
XFILLER_0_111_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1491_ _0301_ _0498_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_33_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2112_ _1075_ _1076_ _1077_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__a21bo_2
XTAP_TAPCELL_ROW_85_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2043_ _1083_ _1084_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nand3_1
XFILLER_0_89_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_708 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1827_ _0791_ _0834_ _0864_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_26_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1758_ _0795_ _0796_ _0754_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_111_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_397 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1689_ _0727_ _0728_ _0691_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_74_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_3249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_2802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_2813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_2775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_166_3728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_166_3739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_863 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_738 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2730_ _0458_ _0431_ _0430_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_109_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2661_ _0383_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__xor2_1
XFILLER_0_124_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1612_ _0647_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nand3_1
XFILLER_0_151_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2592_ _0256_ _0264_ _0257_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1543_ net9 net29 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1474_ _0515_ _0516_ _0513_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2026_ net20 VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__buf_4
XFILLER_0_166_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_159_3587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_618 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_138_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_301 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 mcand[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_4
XFILLER_0_188_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2713_ _0410_ _0414_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2644_ _0331_ _0332_ _0334_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or3_1
XFILLER_0_125_695 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_868 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2575_ _0292_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1526_ _0566_ _0567_ _0525_ _0538_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__a211o_1
XFILLER_0_125_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1457_ net12 VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_4
X_1388_ _1172_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__buf_4
XFILLER_0_184_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2009_ _1040_ _1048_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_607 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_426 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_154_3484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_178_3963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_735 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2360_ _0060_ _0061_ _0016_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__a21oi_1
X_2291_ _0651_ _0622_ _0779_ _0683_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__nand4_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_132_3045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_132_3056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2627_ _0143_ _1108_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_180_4009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2558_ _0223_ _0225_ _0274_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_11_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1509_ _0545_ _0546_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2489_ _0198_ _0199_ _0195_ _0147_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_50_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_168_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_663 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_939 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1860_ _0896_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xor2_2
XFILLER_0_12_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_543 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput12 mcand[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_4
XFILLER_0_24_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1791_ _0828_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__xor2_1
Xinput23 mplier[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_181_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2412_ _0694_ _1108_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2343_ _0039_ _0043_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__xor2_1
X_2274_ _1261_ _1325_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_88_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_164_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_817 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_151_3421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_151_3432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1989_ _0956_ _0959_ _0957_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_160_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_749 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_149_3394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_646 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1912_ _0941_ _0943_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nand2_2
XFILLER_0_155_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1843_ _0751_ _0832_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1774_ _0811_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__nor2_2
XFILLER_0_25_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_680 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2326_ _1288_ _1316_ _0025_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_58_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2257_ _1245_ _1243_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__and2b_1
XFILLER_0_109_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2188_ _1164_ _1165_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_189_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_173_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_164_3689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1490_ _0532_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2111_ _1158_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_33_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2042_ _0989_ _0998_ _0997_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_187_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_174_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1826_ _0862_ _0863_ _0843_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1757_ _0754_ _0795_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and3_2
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1688_ _0691_ _0727_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2309_ _0760_ _0851_ _0922_ _0762_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__a22o_1
XFILLER_0_174_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_863 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_2765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_354 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_166_3729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_79_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_875 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_88_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2660_ _0192_ _1108_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1611_ _0648_ _0649_ _0650_ _1334_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2591_ _0303_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1542_ _0581_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1473_ _0513_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2025_ _1059_ _1066_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_49_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_3190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_165_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_127_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_187_4143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1809_ _0846_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_187_4154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_161_3626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_159_3588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_159_3599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_711 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_157_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_438 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2712_ _0123_ _1109_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__nand2_1
XFILLER_0_171_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2643_ _0357_ _0356_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2b_1
XFILLER_0_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_847 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2574_ _0242_ _0244_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nor2_2
XFILLER_0_125_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1525_ _0525_ _0538_ _0566_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o211a_1
XFILLER_0_121_880 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1456_ _0498_ _0500_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__xnor2_4
X_1387_ _1193_ _1204_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__nor2_1
XFILLER_0_184_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2008_ _1045_ _1046_ _1047_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_3149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_189_4205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_115_2702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_178_3964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_178_3975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_185_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_154_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_166_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_153_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2290_ _0622_ _0712_ _0683_ _0651_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_3046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_3057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2626_ _0345_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2557_ _0271_ _0273_ _0268_ _0270_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_56_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1508_ _0547_ _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__xnor2_1
X_2488_ _0195_ _0147_ _0198_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__o211ai_4
X_1439_ net28 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_108_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_156_3536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_3872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_154_555 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 mcand[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_4
X_1790_ _0743_ _0745_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__or2_2
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput24 mplier[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_172_Right_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2411_ _0114_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_161_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2342_ _0704_ _0041_ _1348_ _1347_ _0822_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__a32oi_4
X_2273_ _1321_ _1324_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__and2b_1
XFILLER_0_165_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_736 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1988_ _1042_ net7 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_151_3433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2609_ _0328_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__nor2_1
XFILLER_0_101_636 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_123_2878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1037 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_151_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_151_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_1111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_187_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_186_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1911_ _0879_ _0948_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__xor2_1
XFILLER_0_139_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1842_ _0819_ _0831_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_13_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1773_ _0806_ _0809_ _0805_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_181_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2325_ _1311_ _1315_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2256_ _1288_ _1316_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_144_3281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2187_ _1228_ _1242_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_178_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_125_2907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_168_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_155_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_864 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2110_ net86 net9 net22 net23 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_33_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2041_ _1081_ _1082_ _1073_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1825_ _0843_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_878 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1756_ _0793_ _0794_ _0723_ _0755_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_4_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1687_ _0725_ _0726_ _0662_ _0664_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_187_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2308_ _1303_ _1304_ _1305_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_116_Left_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2239_ _1295_ _1296_ _1291_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_120_2804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_875 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_Left_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_366 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_252 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_Left_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_169_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_Left_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1610_ _1334_ _0648_ _0649_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand4_2
X_2590_ _0308_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_140_826 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1541_ _0582_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_35_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1472_ net8 net28 net29 net1 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_152_Left_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2024_ _1064_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__or2b_2
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_161_Left_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_3180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_823 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1808_ _0642_ _0649_ _0650_ _0643_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_187_4144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_187_4155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1739_ net18 VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_170_Left_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_2663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_161_3627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_367 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_159_3589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_162_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_572 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_184_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2711_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__inv_2
XFILLER_0_70_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2642_ _0355_ _0353_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__or2b_1
XFILLER_0_140_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2573_ _0289_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_93_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1524_ _0555_ _0565_ _0564_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_892 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_182_4041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1455_ _0499_ _0301_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand2_2
X_1386_ _1042_ _1074_ _1150_ _1183_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_171_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_846 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2007_ _1045_ _1046_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_69_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_767 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_186_Right_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_234 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_278 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_185_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_178_3965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_166_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_153_Right_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_153_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_642 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_907 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_575 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_132_3047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2625_ _0346_ _0285_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2556_ _0268_ _0270_ _0271_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__o211a_1
XFILLER_0_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1507_ _0548_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__and2b_1
X_2487_ _0192_ _0747_ _0196_ _0197_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__nand4_4
XFILLER_0_10_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1438_ net9 net26 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2_1
X_1369_ net17 VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__buf_4
XFILLER_0_179_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_687 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_156_3526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_156_3537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_136_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_173_3873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_154_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput14 mcand[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_2
XFILLER_0_92_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput25 mplier[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_6
XFILLER_0_107_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_740 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2410_ _0694_ _0041_ _0068_ _0067_ _0822_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2341_ _0040_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_8
X_2272_ _1329_ _1333_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_88_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_306 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_173_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1987_ _0949_ _1014_ _1015_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_151_3423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2608_ _0316_ _0314_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__and2b_1
XFILLER_0_140_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_648 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2539_ _0124_ _0233_ _0252_ _0253_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_149_3385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_2879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_922 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xwire71 _0088_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
XFILLER_0_167_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_902 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_771 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1910_ _0874_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__xor2_2
XFILLER_0_139_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1841_ _0813_ _0877_ _0876_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_155_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1772_ net68 _0678_ _0738_ _0803_ _0804_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_108_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2324_ _0022_ _0023_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2255_ _1311_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2186_ _1239_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_900 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_854 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_168_3772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_151_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_876 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2040_ _1073_ _1081_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_187_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1824_ _0859_ _0860_ _0861_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a21o_1
XFILLER_0_170_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1755_ _0723_ _0755_ _0793_ _0794_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a211o_1
XFILLER_0_40_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1686_ _0662_ _0664_ _0725_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a211o_2
XFILLER_0_96_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2307_ _1294_ _1296_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2238_ _1291_ _1295_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__nand3_1
X_2169_ _0759_ _1222_ _1219_ _1220_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__nand4_2
XFILLER_0_95_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_2767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_183_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_171_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_838 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1540_ _1290_ net27 _0117_ _0407_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and4_1
XFILLER_0_22_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1471_ _0999_ net8 _0407_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand4_2
XFILLER_0_5_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_Right_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2023_ _1062_ _1063_ _0986_ _0987_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a211o_1
XFILLER_0_173_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_711 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_3181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_835 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1807_ _1290_ _0117_ net31 net32 VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1738_ _1074_ _0650_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__and2_1
XFILLER_0_142_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_2664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1669_ _0706_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_111_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_161_3628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_161_3639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_711 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_779 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2710_ _0435_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_171_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2641_ _0361_ _0363_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__xor2_2
XFILLER_0_124_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_180_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2572_ _0747_ _0123_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__nand2_2
XFILLER_0_124_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1523_ _0555_ _0564_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nand3_2
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_182_4042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1454_ _0269_ _0053_ _0258_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_71_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1385_ _1031_ _1074_ _1150_ _1183_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_179_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2006_ _0961_ _0962_ _0963_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_171_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_779 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_154_3487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_154_3498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_178_3966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_189_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_357 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_919 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_587 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_132_3048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_132_3059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2624_ _0192_ _0194_ _0822_ _0281_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__and4_1
XFILLER_0_113_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2555_ _0844_ _0272_ _0218_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nand3_2
XFILLER_0_112_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1506_ net10 net27 net11 net26 VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2486_ _0192_ _0747_ _0196_ _0197_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a22o_1
X_1437_ _0364_ _0375_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xnor2_1
X_1368_ net87 VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__buf_4
XFILLER_0_173_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_156_3527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_173_3874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_185_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_831 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 mcand[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_4
XFILLER_0_52_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput26 mplier[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_4
XFILLER_0_13_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_847 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2340_ net6 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__buf_4
XFILLER_0_161_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2271_ _1182_ _1330_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_165_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_173_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1986_ _1018_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_151_3424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2607_ _0313_ _0311_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2538_ _0124_ _0233_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__or4_4
XFILLER_0_11_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_3386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_3397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2469_ _0692_ _0178_ _0001_ _0763_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__a22o_1
XFILLER_0_139_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_717 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_175_3914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_151_538 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_443 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_154_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1840_ _0813_ _0878_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__xnor2_4
XFILLER_0_155_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1771_ _0807_ _0810_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__xnor2_4
XFILLER_0_108_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2323_ _1364_ _1365_ _0019_ _0020_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_97_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2254_ _1228_ _1313_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2185_ _1157_ _1163_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_144_3283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_912 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_168_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_3811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1969_ _0933_ _0975_ net83 _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_172_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_168_3762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_3_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_151_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_663 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_152_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_711 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_148_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1823_ _0859_ _0860_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__nand3_4
XFILLER_0_155_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1754_ _0791_ _0792_ _0770_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_142_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1685_ _0723_ _0724_ _0702_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_41_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2306_ _0002_ _0003_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_163_3670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2237_ _0692_ _0779_ _1292_ _1294_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__nand4_2
XFILLER_0_24_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2168_ _0651_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__buf_4
XFILLER_0_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2099_ _1070_ _1071_ _1145_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o211a_1
XFILLER_0_165_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_722 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1470_ net29 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__buf_6
XFILLER_0_5_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_173_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2022_ _0986_ _0987_ _1062_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_171_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1806_ _0705_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_187_4146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1737_ _0771_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1668_ _0707_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_113_2676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1599_ _1290_ _0117_ net84 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_84_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_161_3629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_93_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_723 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_847 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_804 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_848 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_184_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2640_ _0318_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_514 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_3090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2571_ _0287_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__or2_2
XFILLER_0_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1522_ _0552_ _0554_ _0553_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1453_ _0150_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_71_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1384_ _1010_ _1161_ _1117_ _1172_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__a22o_1
XFILLER_0_179_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2005_ _1043_ _1044_ _1041_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__a21o_1
XFILLER_0_188_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_542 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_154_3499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_171_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire2 _0939_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_1
XFILLER_0_111_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_178_3967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_614 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_599 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_3049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2623_ _0692_ _0126_ _0295_ _0298_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2554_ _1109_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_110_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1505_ net26 net10 net27 net11 VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__and4_1
X_2485_ _0624_ _0685_ _1068_ _1154_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nand4_4
XFILLER_0_10_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1436_ _1021_ net12 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand2_1
X_1367_ net1 VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__buf_8
XFILLER_0_37_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_156_3539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_566 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_173_3864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_173_3875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_901 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_143_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_185_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput16 mcand[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_4
Xinput27 mplier[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_6
XFILLER_0_80_843 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_161_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_691 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2270_ _1185_ _1256_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__o21a_1
XFILLER_0_165_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_420 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_637 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1985_ _0945_ _1017_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_151_3425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_422 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2606_ _0320_ _0327_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__xnor2_4
XFILLER_0_2_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2537_ _0250_ _0251_ _0234_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_149_3387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2468_ _0000_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_149_3398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1419_ _1107_ net26 net27 _0999_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__a22o_1
X_2399_ _1329_ _0034_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_151_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_154_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1770_ _0808_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__or2_2
XFILLER_0_154_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2322_ _1364_ _1365_ _0019_ _0020_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_85_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2253_ _1239_ _1241_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__nor2_1
X_2184_ _1160_ _1162_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_144_3284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1968_ _1003_ _1004_ _0984_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_173_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1899_ _0862_ _0904_ _0935_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_4_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_168_3763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_916 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_160_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_723 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_642 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1822_ _0777_ _0787_ _0786_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_115_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1753_ _0770_ _0791_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1684_ _0702_ _0723_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_146_3324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2305_ _0128_ _0705_ _0000_ _0001_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_163_3660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2236_ _0759_ _0779_ _1292_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__a22o_1
XFILLER_0_135_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ _0759_ _0651_ _1219_ _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2098_ _0772_ _0759_ _1143_ _1144_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_721 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_152_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_160_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xsplit10 _0407_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_15_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_480 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_798 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_181_Right_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_112_Left_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_Left_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_141_3221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2021_ _0774_ _0629_ _1060_ _1061_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_130_Left_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1805_ _0774_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__buf_4
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_187_4147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1736_ _0773_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1667_ _0642_ net88 _0587_ _0643_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_113_2666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_2677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1598_ _0514_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__buf_4
XFILLER_0_111_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2219_ _0772_ _0651_ _0622_ _0683_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_1_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_735 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_816 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_882 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_3080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_152_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2570_ _0623_ _0684_ _0992_ net23 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__and4_1
XFILLER_0_124_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1521_ _0562_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1452_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_182_4044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1383_ _1128_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__buf_4
XFILLER_0_184_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2004_ _1041_ _1043_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_69_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_158_3570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_154_3489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1719_ net15 VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__buf_4
X_2699_ _0405_ _0406_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and3_1
XFILLER_0_112_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_624 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_178_3968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_178_3979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_166_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_762 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2622_ _0341_ _0342_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2553_ _0153_ _0155_ _0217_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1504_ _1096_ net12 VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2484_ _0684_ _1068_ _1154_ _0624_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__a22o_1
X_1435_ _0354_ _0343_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_148_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_156_3529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_173_3865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_913 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput17 mplier[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
Xinput28 mplier[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_4
XFILLER_0_91_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_185_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1984_ _1018_ _1023_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__xor2_4
XFILLER_0_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_151_3426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2605_ _0109_ _0322_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o21a_4
XFILLER_0_24_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2536_ _0234_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_149_3388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2467_ _0694_ _1109_ _0116_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_149_3399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1418_ net87 _1107_ net26 net27 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand4_2
X_2398_ _0102_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__or2_4
XFILLER_0_138_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_914 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_159_Left_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_164_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_740 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_168_Left_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_160_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_177_Left_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_649 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_710 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_186_Left_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_949 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2321_ _0016_ _0017_ _0018_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__o21bai_1
X_2252_ _1239_ _1241_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2183_ _1236_ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__or2_2
XFILLER_0_18_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_186_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_170_3813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1967_ _0984_ _1003_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1898_ _0933_ _0934_ _0914_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_114_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2519_ _0692_ _0047_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_162_Right_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_722 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_802 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_446 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_735 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1821_ _0857_ _0858_ _0849_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__a21o_1
XFILLER_0_154_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1752_ _0788_ _0789_ _0790_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a21o_1
XFILLER_0_154_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_460 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1683_ _0720_ _0721_ _0722_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2304_ _0705_ _0000_ _0001_ _0128_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_163_3661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2235_ _0762_ _0763_ _1293_ _1068_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_163_3672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_136_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2166_ _0762_ _0760_ _0712_ _0780_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nand4_2
XFILLER_0_178_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2097_ _0918_ _0759_ _1143_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__nand4_2
XFILLER_0_178_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_733 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_152_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2020_ _0774_ _0629_ _1060_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_141_3222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_3184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_635 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1804_ _0835_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_187_4148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ _1301_ _0772_ _0774_ _0128_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_130_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_187_4159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1666_ _0643_ _0642_ net88 _0587_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_113_2667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1597_ _0638_ _0501_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2218_ _0650_ _0622_ _0683_ _0649_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2149_ _0772_ _0622_ _0683_ _0774_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a22o_1
XFILLER_0_178_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_174_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_828 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_602 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_153_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_153_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_134_3081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1520_ _0556_ _0561_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__or2_1
XFILLER_0_105_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1451_ _0490_ _0493_ _0494_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_182_4045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1382_ net80 VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__buf_4
XFILLER_0_184_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2003_ _0703_ _0640_ _0622_ _0683_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__nand4_2
XFILLER_0_77_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_2707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1718_ net26 VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2698_ _0423_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__nand2_1
X_1649_ _0681_ _0682_ _0688_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_178_3969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_166_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_181_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_248 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_900 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_914 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_179_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2621_ _0284_ _0285_ _0294_ _0293_ _0292_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_152_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_487 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2552_ _0267_ _0222_ _0265_ _0266_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_23_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1503_ _0542_ _0544_ _0543_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_110_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2483_ _0624_ _0685_ _0192_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__and4_1
XFILLER_0_103_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1434_ net25 net24 net10 net11 VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_173_3866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_363 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_800 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_579 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_181_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput18 mplier[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_2
XFILLER_0_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput29 mplier[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_134_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_176_Right_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_609 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1983_ _1019_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__or2_2
XFILLER_0_184_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_172_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_151_3427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_140_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2604_ _0276_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_479 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2535_ _0248_ _0249_ _0183_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a21o_1
X_2466_ _0083_ _0175_ _0115_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_143_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_149_3389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1417_ _1085_ net9 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and2_1
XFILLER_0_177_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2397_ _0099_ _0101_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_752 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_1105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_917 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2320_ _0016_ _0017_ _0018_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__or3b_2
XFILLER_0_21_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2251_ _1302_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__xor2_4
XFILLER_0_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2182_ _1232_ _1233_ _1235_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_144_3286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_105_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_170_3814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1966_ _1000_ _1001_ _1002_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a21o_1
XFILLER_0_172_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1897_ _0914_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2518_ _0231_ _0232_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__nor2_4
XFILLER_0_110_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2449_ _0155_ _0156_ _0134_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_166_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_734 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_814 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_582 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_174_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_767 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_183_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1820_ _0849_ _0857_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__nand3_2
XFILLER_0_167_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1751_ _0788_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nand3_2
XFILLER_0_52_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1682_ _0720_ _0721_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand3_2
XFILLER_0_64_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_213 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2303_ net23 VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_146_3337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2234_ net19 VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_163_3662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ _0760_ _0712_ _0780_ _0762_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a22o_1
XFILLER_0_135_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_178_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2096_ _0762_ _0763_ _0651_ _0779_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_120_2809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_177_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_152_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_173_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_185_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1949_ _1290_ _0117_ net18 net19 VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__and4_1
XFILLER_0_181_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_583 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xsplit12 _1107_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_8
XPHY_EDGE_ROW_17_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_151_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_152_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_141_3234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_3196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_474 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1803_ _0836_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_647 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1734_ _0587_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_187_4149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1665_ _0704_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1596_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__buf_4
XFILLER_0_141_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2217_ _1273_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_53_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2148_ _1198_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_178_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2079_ _0703_ net3 VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_534 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_496 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_62_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_544 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_71_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_80_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_3082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_168_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1450_ _0490_ _0493_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1381_ _1139_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__inv_2
XFILLER_0_93_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_160_3610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2002_ _0640_ _0622_ _0683_ _0703_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a22o_1
XFILLER_0_165_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_2708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1717_ _0704_ _0501_ _0708_ _0707_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a31o_1
X_2697_ _0387_ _0422_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1648_ _0681_ _0682_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_1_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1579_ _0560_ _0579_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_6_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_761 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_923 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_157_Right_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_185_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_912 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_580 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2620_ _0335_ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_926 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2551_ _0265_ _0266_ _0267_ _0222_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__o211a_1
XFILLER_0_140_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1502_ _0542_ _0543_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_110_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2482_ _1068_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__buf_2
X_1433_ net80 _1290_ _0117_ _1128_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_128_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_187_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_173_3878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_375 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2749_ _0456_ _0462_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_41_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 mplier[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_4
XFILLER_0_18_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_185_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1982_ _0947_ _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__nor2_1
XFILLER_0_145_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_151_3428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_3439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2603_ _0173_ _0321_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_140_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2534_ _0183_ _0248_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2465_ _0085_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__inv_2
XFILLER_0_177_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1416_ _0139_ _0150_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__nor2_1
X_2396_ _0099_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
XFILLER_0_177_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_175_3918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire65 net43 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_4
XFILLER_0_38_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_835 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_904 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_764 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_642 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_166_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_720 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_594 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_929 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2250_ _1308_ _1309_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2181_ _1232_ _1233_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_2840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_172_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1965_ _1000_ _1001_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__nand3_4
XFILLER_0_114_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_172_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1896_ _0930_ _0931_ _0932_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_734 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_168_3766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2517_ _0230_ _0174_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_168_3777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2448_ _0134_ _0155_ _0156_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__and3_1
X_2379_ _0066_ _0081_ _0082_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__nand3_2
XFILLER_0_75_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_798 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_826 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_325 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_594 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_85_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_242 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_584 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_183_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1750_ _0710_ _0719_ _0718_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_53_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_154_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1681_ _0646_ _0658_ _0657_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_189_4180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2302_ _0992_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_146_3327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_3338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2233_ _0760_ _0780_ _0851_ _0762_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a22o_1
XFILLER_0_139_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_163_3663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2164_ _1152_ _1153_ _1155_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_136_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2095_ _0760_ _0650_ _0712_ _0762_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a22o_1
XFILLER_0_178_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_100_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_779 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1948_ _0642_ _0712_ net19 _0643_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_32_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1879_ _0915_ _0916_ _0501_ _0772_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_31_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xsplit13 _0999_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_15_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_564 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_556 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_3197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_143_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1802_ _0837_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xor2_2
XFILLER_0_155_486 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1733_ _1301_ _0128_ _0772_ _0587_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1664_ _0501_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_113_2669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_165_3703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1595_ net27 VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_165_3714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2216_ _0638_ net6 VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2147_ _0758_ net6 VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2078_ _1122_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_178_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_634 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_173_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_157_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1380_ _1010_ _1096_ _1117_ _1128_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__and4_1
XFILLER_0_120_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_3600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_160_3611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2001_ _0637_ net3 VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__and2_1
XFILLER_0_171_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_852 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_158_3562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_158_3573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2765_ _1237_ _0492_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__nor2_4
XFILLER_0_53_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1716_ _0696_ _0698_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__or2_2
X_2696_ _0387_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__or2_1
XFILLER_0_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1647_ _0686_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nor2_1
XFILLER_0_111_353 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1578_ _0573_ _0578_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_181_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_935 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_144_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_592 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_153_3470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_938 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2550_ _0211_ _0212_ _0209_ _0210_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__a211o_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1501_ _0539_ _0541_ _0540_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_110_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2481_ _1293_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_110_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1432_ _0323_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2748_ _0454_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__inv_2
XFILLER_0_131_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_169_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2679_ _0382_ _0381_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_179_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_526 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_155_3510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1981_ _0814_ _0875_ _0874_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_145_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_3429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2602_ _0277_ _0228_ _0229_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__or3b_1
XFILLER_0_12_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_768 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2533_ _0245_ _0246_ _0240_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2464_ _0104_ _0109_ _0170_ _0173_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o31a_1
XFILLER_0_48_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1415_ _1021_ _1172_ _1301_ _0128_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__and4_2
XFILLER_0_48_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2395_ _1337_ _0031_ _0100_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_177_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_119_Left_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_189_993 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xwire66 net37 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_175_3919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_916 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_Left_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_Left_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_732 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_146_Left_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_155_Left_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2180_ _1074_ net23 _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_144_3288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_3299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_177_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_164_Left_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_170_3816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1964_ _0920_ _0929_ _0928_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1895_ _0930_ _0931_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand3_4
XFILLER_0_172_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2516_ _0174_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_168_3767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_173_Left_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2447_ _0153_ _0154_ _0135_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2378_ _0079_ _0080_ _0071_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__a21o_1
XFILLER_0_166_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_182_Left_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_187_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_254 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1680_ _0718_ _0719_ _0710_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_189_4192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2301_ _1362_ _1363_ _1345_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_146_3328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_3339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2232_ _1229_ _1230_ _1231_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_40_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_163_3675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2163_ _1144_ _1145_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__nand2_2
XFILLER_0_174_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2094_ _1061_ _1062_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__nand2_2
XFILLER_0_178_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_186_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1947_ _0976_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1878_ _1290_ _0117_ net32 net18 VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and4_2
XFILLER_0_82_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_896 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_177_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xsplit14 _0514_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_17_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_3198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1801_ _0504_ _0838_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_183_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1732_ _0649_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_117_2740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1663_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__buf_4
XFILLER_0_151_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1594_ _0627_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_165_3704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2215_ _1271_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2146_ _1196_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__nor2_1
XFILLER_0_178_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_883 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2077_ _1161_ net6 VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_646 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_165_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_164_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_3095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_182_4059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_3601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_3612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2000_ _1038_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_158_3563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_170_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2764_ _1042_ _1117_ _1226_ _1010_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_171_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1715_ _0702_ _0723_ _0724_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nand3_2
XFILLER_0_112_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2695_ _0416_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1646_ _1031_ _1226_ _0624_ _0685_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and4_1
XFILLER_0_111_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1577_ _0616_ _0619_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_171_Right_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer10 _0601_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_2
XFILLER_0_69_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2129_ _1026_ _1024_ _1102_ _1103_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__o211a_1
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_694 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_153_3460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1500_ _0513_ _0516_ _0515_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2480_ _0189_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_110_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1431_ _0301_ _0312_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__and2_4
XFILLER_0_121_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_170_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_177_3950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_148_538 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_173_3869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_171_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2747_ _0475_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__nand2_4
XFILLER_0_147_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2678_ _0390_ _0392_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1629_ _0602_ _0604_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_1_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_609 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_538 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_166_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_631 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_867 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_161_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_184_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1980_ _0811_ _0812_ _0878_ _0948_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__o211a_4
XFILLER_0_184_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2601_ _0104_ _0170_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__or3_1
Xrebuffer1 _0159_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd2_1
XFILLER_0_153_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2532_ _0240_ _0245_ _0246_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nand3_2
XFILLER_0_122_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2463_ _0102_ _0168_ _0169_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_139_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1414_ _1172_ _1301_ _0128_ _1021_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__a22oi_1
X_2394_ _0028_ _0030_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__or2b_1
XFILLER_0_48_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_175_3909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire67 net63 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_4
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_163_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_172_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_928 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_950 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_132_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_642 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_744 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_656 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_3289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1963_ _0997_ _0998_ _0989_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_170_3806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1894_ _0849_ _0858_ _0857_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_4_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2515_ _0228_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_168_3768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_168_3779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2446_ _0135_ _0153_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__nand3_2
XFILLER_0_166_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2377_ _0071_ _0079_ _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__nand3_2
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_148_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_183_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_183_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_151_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2300_ _1345_ _1362_ _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_146_3329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2231_ _1220_ _1223_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2162_ _1213_ _1214_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__nor2_2
X_2093_ _1138_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__and2b_2
XFILLER_0_177_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1946_ _0981_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__or2b_1
XFILLER_0_161_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1877_ _0642_ _0650_ _0712_ _0643_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_114_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2429_ _0048_ _0057_ _0056_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_32_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_807 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_165_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_151_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_185_Right_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_544 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_864 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_588 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_184_4090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_3237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_156_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1800_ _0514_ _0762_ _0760_ _0703_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_861 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_740 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1731_ _0705_ _0694_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_117_2741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_170_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_152_Right_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1662_ _0407_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__buf_4
XFILLER_0_111_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1593_ _0628_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2214_ _0704_ _0640_ net4 _0887_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2145_ _0638_ _0704_ _0820_ _0887_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_1_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2076_ _1120_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1929_ _1161_ net3 _0894_ _0893_ _0622_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__a32o_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_330 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_680 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_856 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_182_4049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_160_3602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_923 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_182_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_691 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2763_ _0491_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1714_ _0742_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_170_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2694_ _0419_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_152_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_311 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1645_ _1226_ _0624_ _0685_ _1031_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_151_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1576_ _0535_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__or2_4
XFILLER_0_111_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 _0429_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
X_2128_ _1177_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_174_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2059_ _1026_ _1102_ _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__and3_1
XFILLER_0_178_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_734 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1430_ _0086_ _0290_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_184_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2746_ _0448_ _0463_ _0474_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand3_2
XFILLER_0_83_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2677_ _0344_ _0350_ _0389_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__or3_1
XFILLER_0_44_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1628_ _0668_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__and2_1
XFILLER_0_100_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1559_ _0555_ _0566_ _0600_ net92 VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_179_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_704 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_3033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_184_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_155_3501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_698 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2600_ _0230_ _0278_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nand2_1
XFILLER_0_181_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer2 _0354_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_1
XFILLER_0_12_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2531_ _0243_ _0244_ _0197_ _0199_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_12_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2462_ _0170_ _0171_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__xnor2_4
X_1413_ _0117_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__buf_4
XFILLER_0_20_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2393_ _0038_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xwire68 _0677_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_2
XFILLER_0_175_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_665 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2729_ _0365_ _0366_ _0393_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_147_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_668 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _0989_ _0997_ _0998_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_170_3807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1893_ _0928_ _0929_ _0920_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2514_ _0113_ _0165_ _0164_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_168_3769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2445_ _0151_ _0152_ _0136_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2376_ _0077_ _0078_ _0072_ _0073_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a211o_1
XFILLER_0_166_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_189_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_182_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_166_Right_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_148_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_163_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_155_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_155_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_167_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_182_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_182_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_512 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_189_4194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2230_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__nor2_2
XFILLER_0_40_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2161_ _1211_ _1212_ _1194_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_163_3666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_174_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2092_ _1136_ _1137_ _1118_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_159_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_159_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1945_ _0979_ _0980_ _0916_ _0917_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1876_ _0905_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xor2_4
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2428_ _0079_ _0081_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_819 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2359_ _0705_ _0001_ _0058_ _0059_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_32_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_774 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_166_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_876 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_184_4080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_139_3189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_873 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_752 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1730_ _0756_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__xor2_2
XFILLER_0_124_832 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_2742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_142_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1661_ _0693_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__xor2_2
XFILLER_0_151_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1592_ _0630_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_165_3706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2213_ _0694_ _0820_ _0887_ _0704_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_56_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2144_ _0704_ _0820_ _0887_ _0638_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_1_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2075_ _0758_ _0638_ net4 _0887_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__and4_1
XFILLER_0_163_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1928_ _0962_ _0963_ _0961_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1859_ _0825_ _0826_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_188_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_157_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_149_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_180_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_802 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_868 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_160_3603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_935 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2762_ _0619_ _0489_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_2
XFILLER_0_5_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1713_ _0751_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__or2_1
X_2693_ _0194_ _1108_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1644_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__buf_6
XFILLER_0_111_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1575_ _0571_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_890 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer12 _0604_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_0_178_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2127_ _0950_ _1101_ _1100_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_13_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2058_ _1100_ _1101_ _0950_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_159_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_157_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_3126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_153_3473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_152_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_177_3941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_743 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2745_ _0448_ _0463_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2676_ _0396_ _0401_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__xor2_4
XFILLER_0_78_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1627_ _0666_ _0667_ _0626_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1558_ _0598_ _0599_ _0580_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__o21a_1
XFILLER_0_185_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1489_ _0499_ _0498_ _0530_ _0531_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_20_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_147_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_666 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_716 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_481 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_155_3513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer3 net76 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2530_ _0197_ _0199_ _0243_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a211o_2
XFILLER_0_11_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2461_ _0104_ _0109_ _0102_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_121_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1412_ net11 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__buf_6
XFILLER_0_139_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2392_ _0094_ _0096_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_147_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_677 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_716 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_144_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_171_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2728_ _0394_ _0395_ _0432_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__or3_1
XFILLER_0_131_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2659_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_150_3410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_115_Left_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_148_3361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_Left_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1961_ _0994_ _0995_ _0996_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__a21o_1
XFILLER_0_157_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_170_3819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1892_ _0920_ _0928_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand3_2
XFILLER_0_141_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_133_Left_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2513_ _0225_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2444_ _0136_ _0151_ _0152_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__nand3_2
X_2375_ _0072_ _0073_ _0077_ _0078_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_166_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_142_Left_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_149_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_151_Left_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_160_Left_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_182_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_524 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2160_ _1194_ _1211_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_163_3667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_163_3678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ _1118_ _1136_ _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__nor3_1
Xmax_cap1 _0677_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_158_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_159_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_185_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_498 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1944_ _0916_ _0917_ _0979_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__o211a_1
XFILLER_0_127_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1875_ _0911_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__and2b_1
XFILLER_0_154_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_153_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2427_ _0060_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__xor2_2
XFILLER_0_86_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2358_ _0705_ _0047_ _0058_ _0059_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_32_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2289_ _1277_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_750 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_786 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_706 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_764 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_2743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_844 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1660_ _0695_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__xor2_2
XFILLER_0_145_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_151_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1591_ _0631_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_165_3707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2212_ _1217_ _1225_ _1224_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2143_ _1142_ _1148_ _1147_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_1_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2074_ _0638_ _0820_ _0887_ _0758_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_402 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_161_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1927_ _0961_ _0962_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nand3_1
XFILLER_0_45_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_170_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1858_ _0892_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xor2_2
XFILLER_0_115_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_188_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_387 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_836 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1789_ _0826_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__nor2_2
XFILLER_0_13_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_363 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_138_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_3098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_814 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_160_3604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_172_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_947 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_158_3566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_156_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_183_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2761_ _0535_ _0618_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1712_ _0687_ _0750_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2692_ _0378_ _0417_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_152_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_1 _0319_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_112_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1643_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__buf_6
XFILLER_0_111_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1574_ _0530_ _0532_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer13 _0600_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd1_1
X_2126_ _1110_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2057_ _0950_ _1100_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__or3_4
XFILLER_0_178_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_867 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_161_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_169_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_530 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_3127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_3138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_189_Left_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput60 net60 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_128_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_177_3942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_177_3953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_149_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_755 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2744_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2675_ _0327_ _0398_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_169_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1626_ _0626_ _0666_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__nand3_2
XFILLER_0_83_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1557_ _0580_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nor3_4
XFILLER_0_185_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1488_ _0499_ _0498_ _0530_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_94_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2109_ _1074_ _0992_ net23 _1117_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_90_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_678 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_131_3024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_728 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_172_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_157_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_155_3514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_339 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer4 _0505_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_2
XFILLER_0_125_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2460_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__or2b_4
XFILLER_0_107_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1411_ _0086_ _0097_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__nor2_4
XFILLER_0_20_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2391_ _1343_ _0027_ _0095_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o21a_1
XFILLER_0_139_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_144_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2727_ _0454_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or2_2
XFILLER_0_73_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_452 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2658_ _0337_ _0339_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1609_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_39_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2589_ _1222_ _1108_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_39_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_179_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_167_603 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_759 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_148_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_181_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_163_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_148_3362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_612 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1960_ _0994_ _0995_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nand3_1
XFILLER_0_56_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_170_3809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1891_ _0925_ _0926_ _0927_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_180_Right_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2512_ _0223_ _0224_ _0176_ _0177_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a211o_1
XFILLER_0_11_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2443_ _0148_ _0149_ _0142_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2374_ _1222_ _0746_ _0074_ _0076_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__nand4_4
XFILLER_0_120_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_182_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_770 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_145_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_162_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_160_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_886 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_536 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_151_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_163_3679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2090_ _1134_ _1135_ _1119_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1943_ _0640_ _0629_ _0977_ _0978_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_161_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1874_ _0909_ _0910_ _0846_ _0906_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a211o_1
XFILLER_0_126_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2426_ _0131_ _0132_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2357_ _0056_ _0057_ _0048_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2288_ _1349_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__xor2_1
XFILLER_0_169_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_762 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_710 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_798 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_184_4093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_3229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_718 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_182_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_117_2744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_396 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_856 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1590_ _1312_ net13 _0557_ _1096_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a22o_1
XFILLER_0_111_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_165_3719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2211_ _1207_ _1209_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__and2_1
XFILLER_0_147_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2142_ _1132_ _1134_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__and2_1
XFILLER_0_179_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2073_ _1059_ _1065_ _1064_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__a21o_1
XFILLER_0_163_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_174_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_189_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_743 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1926_ _0637_ net84 net16 _0683_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__nand4_2
XFILLER_0_44_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1857_ _0623_ _0893_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1788_ _1172_ _0746_ _0824_ _0825_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_188_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_848 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2409_ _0065_ _0084_ _0083_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_51_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_169_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_754 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_3099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_186_4133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_826 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_140_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_160_3605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_156_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_356 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_158_3578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_183_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2760_ _0486_ _0488_ _0480_ _0485_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__a211o_4
XFILLER_0_143_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1711_ _0687_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2691_ _0369_ _0372_ _0370_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_152_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1642_ net2 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__buf_6
XANTENNA_2 _0407_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_112_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1573_ _0614_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer14 _0612_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
X_2125_ _1174_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2056_ _1098_ _1099_ _1012_ _1014_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_146_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1909_ _0945_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_163_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_181_4030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_178_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165_542 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_3128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_136_3139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_770 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput50 net50 VGND VGND VPWR VPWR product[25] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput61 net61 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_177_3954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_14 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_183_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2743_ _0469_ _0470_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2674_ _0318_ _0399_ _0360_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1625_ _0664_ _0665_ _0598_ net94 VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__a211o_1
XFILLER_0_78_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1556_ _0595_ _0596_ _0597_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_185_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1487_ _0527_ _0528_ _0529_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_154_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2108_ _1152_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_178_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_178_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2039_ _1078_ _1079_ _1080_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_46_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_175_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_3025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_921 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_185_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_155_3515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_161_Right_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_172_3840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_172_3851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer5 _0917_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1410_ _1248_ _0075_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_2_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2390_ _0024_ _0026_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_2949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_921 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_155_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_189_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_818 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_175_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_184_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2726_ _0424_ _0427_ _0453_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_280 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_965 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2657_ _0341_ _0342_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1608_ net32 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__buf_4
XFILLER_0_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2588_ _0306_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_39_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1539_ net27 _0117_ net84 _1290_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_129_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_167_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_179_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_147_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_443 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_3401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_150_3412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_148_3363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_176_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1890_ _0925_ _0926_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nand3_1
XFILLER_0_172_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_181_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2511_ _0176_ _0177_ _0223_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_12_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2442_ _0142_ _0148_ _0149_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__nand3_2
XFILLER_0_110_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2373_ _1222_ _0746_ _0074_ _0076_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_155_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_865 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_729 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_65_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2709_ _0281_ _0178_ _0041_ _0047_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_143_3260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_143_3271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_186_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_179_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_168_979 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_898 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_150_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_167_3750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_163_3669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_174_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1942_ _0640_ _0629_ _0977_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__nand4_2
XFILLER_0_127_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1873_ _0846_ _0906_ _0909_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__o211a_1
XFILLER_0_142_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_141_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2425_ _0129_ _0130_ _0054_ _0122_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_86_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_787 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2356_ _0048_ _0056_ _0057_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__nand3_2
XFILLER_0_19_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2287_ _0704_ net6 VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_168_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_177_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_722 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_854 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_141_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_765 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_184_4094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_821 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_182_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_164_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_151_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_165_3709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2210_ _1265_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__xnor2_2
X_2141_ _1190_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_89_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2072_ _1048_ _1050_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_710 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_158_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_1061 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_174_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1925_ net84 net16 net2 _0637_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_802 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_621 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1856_ _0637_ net16 net2 _1312_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1787_ _0824_ _0825_ _1172_ net3 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2408_ _0704_ _1109_ _0044_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_51_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2339_ _1345_ _1363_ _1362_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_905 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_538 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_177_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_949 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_138_3170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_164_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_813 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_164_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_3089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_186_4134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_132_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xsplit6 _1085_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_160_3606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_663 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_713 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_158_3568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_368 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_155_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_757 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_171_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1710_ _0745_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_621 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2690_ _0414_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1641_ _0627_ _0635_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_3 _0746_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_151_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_849 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1572_ net81 net95 _0532_ _0607_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_0_10_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_175_Right_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2124_ _1033_ _1097_ _1095_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2055_ _1012_ _1014_ _1098_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_49_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_159_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_993 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_146_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1908_ _0943_ _0944_ _0870_ net70 VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a211o_1
XFILLER_0_161_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1839_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__nor2_4
XFILLER_0_114_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_4020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_181_4031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_392 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_600 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_170_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_184_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_165_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_136_3129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_705 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_153_3465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_3476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput40 net40 VGND VGND VPWR VPWR product[16] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR product[26] sky130_fd_sc_hd__clkbuf_4
Xoutput62 net62 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_893 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_188_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_188_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_160_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2742_ _0469_ _0470_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_790 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2673_ _0330_ _0358_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__or2b_1
XFILLER_0_140_911 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_152_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1624_ _0598_ net94 _0664_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_151_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1555_ _0595_ _0596_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and3_4
XFILLER_0_111_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1486_ _0527_ _0528_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__nand3_4
XFILLER_0_185_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2107_ _1153_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2038_ _1078_ _1079_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_178_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_175_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_162_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_3026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_3037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_157_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_155_3505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_155_3516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_172_3841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_165_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_172_3852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_941 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer6 _0568_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_24_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_793 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_933 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_977 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_154_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_175_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_103_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_172_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_184_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2725_ _0424_ _0427_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_112_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2656_ _0378_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_977 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1607_ net31 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2587_ _0304_ _0252_ _0305_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_121_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1538_ _1312_ net12 VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__nand2_1
X_1469_ net9 net27 VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__and2_1
XFILLER_0_129_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_175_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_150_3402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_3413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_162_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_148_3364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_3375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_176_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_186_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139_841 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_154_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_166_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_165_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_183_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_180_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2510_ _0221_ _0222_ net75 net69 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a211o_1
XFILLER_0_141_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2441_ _0146_ _0147_ _0076_ _0078_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_11_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2372_ _0623_ _0779_ _0684_ _1293_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__nand4_4
XFILLER_0_120_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_189_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_188_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_189_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_111_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_176_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_82_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_176_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_157_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_877 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_590 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2708_ _0178_ _0041_ _0047_ _0281_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_113_741 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_120_Left_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2639_ _0327_ _0320_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__or2b_1
XFILLER_0_11_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_143_3261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_3272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_168_925 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_179_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_139_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_147_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_162_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_189_4187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_189_4198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_150_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_785 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_167_3740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_1035 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_167_3751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_152_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_186_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_158_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_174_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_139_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1941_ _0503_ _0649_ _0587_ _0760_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__nand4_2
XFILLER_0_72_904 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_173_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1872_ _0703_ _0629_ _0907_ _0908_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a22o_1
XFILLER_0_182_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2424_ _0054_ _0122_ _0129_ _0130_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o211a_1
XFILLER_0_177_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2355_ _0052_ _0055_ _0003_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_32_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2286_ _0820_ _1347_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_1085 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_176_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149_468 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_176_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_145_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_734 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_899 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_145_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_166_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_144_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_1057 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_160_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_189_Right_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_1029 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_184_4084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_184_4095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_3301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_3312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_173_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_834 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_168_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_945 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_155_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_989 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_164_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_170_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_2746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_145_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_869 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_180_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_150_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_156_Right_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2140_ _1161_ _1108_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__nand2_2
XFILLER_0_79_1063 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2071_ _1114_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_163_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_152_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_709 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_158_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_158_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_1091 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_174_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1924_ _1312_ net3 VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_173_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_814 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_1007 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1855_ _1312_ _0637_ net2 VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1786_ _1096_ _1312_ net16 net2 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and4_1
XFILLER_0_12_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_142_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_772 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2407_ _0039_ _0043_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2338_ _0638_ _1109_ _1341_ _1340_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__a31o_1
X_2269_ _1177_ _1178_ _1185_ _1256_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_137_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_177_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_917 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_177_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_3160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_153_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_3171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_146_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_152_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_825 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_1119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_357 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_186_4135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_160_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_160_3618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_187_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_725 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_753 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_158_3569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_156_769 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_797 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_155_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1640_ _0628_ _0634_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _0916_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_151_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1571_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__buf_6
XFILLER_0_50_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_158_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_1073 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_837 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_184_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2123_ _1116_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__xor2_2
XFILLER_0_117_1001 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_156_1061 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2054_ _1095_ _1097_ _1033_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1045 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_1033 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_1089 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_1017 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_1077 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_159_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_174_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_881 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_937 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_961 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1907_ _0870_ net70 _0943_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_44_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_161_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_981 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_853 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_163_1021 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1838_ _0874_ _0875_ _0814_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_897 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_1005 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_163_1065 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_1113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1769_ _0606_ _0735_ _0734_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_92_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_1049 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_181_4021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_181_4032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_1093 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_1101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_185_809 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_178_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_1009 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_1117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_736 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_177_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_153_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_180_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_3466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_149_Left_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_153_3477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_180_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_181_1121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_142_1105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_973 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput41 net41 VGND VGND VPWR VPWR product[17] sky130_fd_sc_hd__clkbuf_4
Xoutput52 net52 VGND VGND VPWR VPWR product[27] sky130_fd_sc_hd__clkbuf_4
Xoutput63 net67 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_158_Left_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_129_2981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_940 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_188_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_177_3956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_909 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_171_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_1037 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_143_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_167_Left_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_183_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2741_ _0410_ _0414_ _0440_ _0442_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__o22a_1
XFILLER_0_81_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_953 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_143_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_737 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_140_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2672_ _0320_ _0361_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_951 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_140_923 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1623_ _0662_ _0663_ _0636_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_151_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_781 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1554_ _0546_ _0551_ _0545_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1485_ _0150_ _0496_ _0495_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_176_Left_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_185_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
.ends
